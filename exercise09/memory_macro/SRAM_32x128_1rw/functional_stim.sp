* Functional test stimulus file for 5ns period

* TT process corner
.include "/home/schmidpa/Desktop/ESES/09/assets/OpenRAM/technology/freepdk45/models/tran_models/models_nom/PMOS_VTG.inc"
.include "/home/schmidpa/Desktop/ESES/09/assets/OpenRAM/technology/freepdk45/models/tran_models/models_nom/NMOS_VTG.inc"
.include "SRAM_32x128_1rw.sp"

* Global Power Supplies
Vvdd vdd 0 1.1

*Nodes gnd and 0 are the same global ground node in ngspice/hspice/xa. Otherwise, this source may be needed.
*Vgnd gnd 0 0.0

* Instantiation of the SRAM
XSRAM_32x128_1rw din0_0 din0_1 din0_2 din0_3 din0_4 din0_5 din0_6 din0_7 din0_8 din0_9 din0_10 din0_11 din0_12 din0_13 din0_14 din0_15 din0_16 din0_17 din0_18 din0_19 din0_20 din0_21 din0_22 din0_23 din0_24 din0_25 din0_26 din0_27 din0_28 din0_29 din0_30 din0_31 a0_0 a0_1 a0_2 a0_3 a0_4 a0_5 a0_6 CSB0 WEB0 clk0 dout0_0 dout0_1 dout0_2 dout0_3 dout0_4 dout0_5 dout0_6 dout0_7 dout0_8 dout0_9 dout0_10 dout0_11 dout0_12 dout0_13 dout0_14 dout0_15 dout0_16 dout0_17 dout0_18 dout0_19 dout0_20 dout0_21 dout0_22 dout0_23 dout0_24 dout0_25 dout0_26 dout0_27 dout0_28 dout0_29 dout0_30 dout0_31 vdd gnd SRAM_32x128_1rw

* SRAM output loads
CD00 dout0_0  0 0.8364f
CD01 dout0_1  0 0.8364f
CD02 dout0_2  0 0.8364f
CD03 dout0_3  0 0.8364f
CD04 dout0_4  0 0.8364f
CD05 dout0_5  0 0.8364f
CD06 dout0_6  0 0.8364f
CD07 dout0_7  0 0.8364f
CD08 dout0_8  0 0.8364f
CD09 dout0_9  0 0.8364f
CD010 dout0_10  0 0.8364f
CD011 dout0_11  0 0.8364f
CD012 dout0_12  0 0.8364f
CD013 dout0_13  0 0.8364f
CD014 dout0_14  0 0.8364f
CD015 dout0_15  0 0.8364f
CD016 dout0_16  0 0.8364f
CD017 dout0_17  0 0.8364f
CD018 dout0_18  0 0.8364f
CD019 dout0_19  0 0.8364f
CD020 dout0_20  0 0.8364f
CD021 dout0_21  0 0.8364f
CD022 dout0_22  0 0.8364f
CD023 dout0_23  0 0.8364f
CD024 dout0_24  0 0.8364f
CD025 dout0_25  0 0.8364f
CD026 dout0_26  0 0.8364f
CD027 dout0_27  0 0.8364f
CD028 dout0_28  0 0.8364f
CD029 dout0_29  0 0.8364f
CD030 dout0_30  0 0.8364f
CD031 dout0_31  0 0.8364f

* Important signals for debug
* bl:	xsram_32x128_1rw.xbank0.bl_0_0
* br:	xsram_32x128_1rw.xbank0.br_0_0
* s_en:	xsram_32x128_1rw.s_en
* q:	xSRAM_32x128_1rw.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q
* qbar:	xSRAM_32x128_1rw.xbank0.xbitcell_array.xreplica_bitcell_array.xbitcell_array.xbit_r0_c0.Q_bar

* Sequence of operations
*	Idle during cycle 0 (0ns - 5ns)
*	Writing 11111110100101011000110111101010  to  address 1111101 (from port 0) during cycle 1 (5ns - 10ns)
*	Writing 00010010000110011101000011010101  to  address 1111011 (from port 0) during cycle 2 (10ns - 15ns)
*	Writing 10110110011111001111000100110010  to  address 1111011 (from port 0) during cycle 3 (15ns - 20ns)
*	Reading 10110110011111001111000100110010 from address 1111011 (from port 0) during cycle 4 (20ns - 25ns)
*	Writing 01110100001001011000000000100111  to  address 1111101 (from port 0) during cycle 5 (25ns - 30ns)
*	Reading 01110100001001011000000000100111 from address 1111101 (from port 0) during cycle 6 (30ns - 35ns)
*	Reading 01110100001001011000000000100111 from address 1111101 (from port 0) during cycle 8 (40ns - 45ns)
*	Writing 11111000101100011001100000101011  to  address 0000001 (from port 0) during cycle 9 (45ns - 50ns)
*	Reading 01110100001001011000000000100111 from address 1111101 (from port 0) during cycle 11 (55ns - 60ns)
*	Reading 01110100001001011000000000100111 from address 1111101 (from port 0) during cycle 12 (60ns - 65ns)
*	Writing 10010011011010101101111100010010  to  address 1111101 (from port 0) during cycle 14 (70ns - 75ns)
*	Reading 10110110011111001111000100110010 from address 1111011 (from port 0) during cycle 15 (75ns - 80ns)
*	Reading 10010011011010101101111100010010 from address 1111101 (from port 0) during cycle 17 (85ns - 90ns)
*	Reading 10010011011010101101111100010010 from address 1111101 (from port 0) during cycle 18 (90ns - 95ns)
*	Reading 10010011011010101101111100010010 from address 1111101 (from port 0) during cycle 19 (95ns - 100ns)
*	Reading 11111000101100011001100000101011 from address 0000001 (from port 0) during cycle 20 (100ns - 105ns)
*	Reading 10110110011111001111000100110010 from address 1111011 (from port 0) during cycle 22 (110ns - 115ns)
*	Reading 11111000101100011001100000101011 from address 0000001 (from port 0) during cycle 23 (115ns - 120ns)
*	Reading 10010011011010101101111100010010 from address 1111101 (from port 0) during cycle 24 (120ns - 125ns)
*	Writing 00010111111101010101010011011011  to  address 1111011 (from port 0) during cycle 25 (125ns - 130ns)
*	Reading 00010111111101010101010011011011 from address 1111011 (from port 0) during cycle 26 (130ns - 135ns)
*	Writing 10010100110001100111110001111001  to  address 1111110 (from port 0) during cycle 27 (135ns - 140ns)
*	Reading 10010100110001100111110001111001 from address 1111110 (from port 0) during cycle 28 (140ns - 145ns)
*	Writing 10011110000100111010100001000000  to  address 1111011 (from port 0) during cycle 29 (145ns - 150ns)
*	Reading 11111000101100011001100000101011 from address 0000001 (from port 0) during cycle 30 (150ns - 155ns)
*	Reading 10010100110001100111110001111001 from address 1111110 (from port 0) during cycle 33 (165ns - 170ns)
*	Reading 11111000101100011001100000101011 from address 0000001 (from port 0) during cycle 34 (170ns - 175ns)
*	Reading 10010011011010101101111100010010 from address 1111101 (from port 0) during cycle 35 (175ns - 180ns)
*	Reading 10010100110001100111110001111001 from address 1111110 (from port 0) during cycle 36 (180ns - 185ns)
*	Reading 10010011011010101101111100010010 from address 1111101 (from port 0) during cycle 38 (190ns - 195ns)
*	Writing 10101110010101110010000011000001  to  address 0000010 (from port 0) during cycle 39 (195ns - 200ns)
*	Reading 10011110000100111010100001000000 from address 1111011 (from port 0) during cycle 40 (200ns - 205ns)
*	Reading 10011110000100111010100001000000 from address 1111011 (from port 0) during cycle 41 (205ns - 210ns)
*	Writing 01110010101100111001100101100101  to  address 0000010 (from port 0) during cycle 44 (220ns - 225ns)
*	Writing 01001110111111100001101111110011  to  address 1111101 (from port 0) during cycle 49 (245ns - 250ns)
*	Reading 01110010101100111001100101100101 from address 0000010 (from port 0) during cycle 50 (250ns - 255ns)
*	Reading 11111000101100011001100000101011 from address 0000001 (from port 0) during cycle 51 (255ns - 260ns)
*	Writing 10111001011001010010101100100110  to  address 1111100 (from port 0) during cycle 52 (260ns - 265ns)
*	Reading 11111000101100011001100000101011 from address 0000001 (from port 0) during cycle 53 (265ns - 270ns)
*	Reading 10010100110001100111110001111001 from address 1111110 (from port 0) during cycle 54 (270ns - 275ns)
*	Reading 01001110111111100001101111110011 from address 1111101 (from port 0) during cycle 56 (280ns - 285ns)
*	Reading 11111000101100011001100000101011 from address 0000001 (from port 0) during cycle 57 (285ns - 290ns)
*	Writing 00101100010100011100000011011010  to  address 1111011 (from port 0) during cycle 59 (295ns - 300ns)
*	Writing 10111111111011010111100011101101  to  address 1111110 (from port 0) during cycle 60 (300ns - 305ns)
*	Reading 01001110111111100001101111110011 from address 1111101 (from port 0) during cycle 61 (305ns - 310ns)
*	Reading 00101100010100011100000011011010 from address 1111011 (from port 0) during cycle 62 (310ns - 315ns)
*	Writing 01111100011000111011000011110000  to  address 0000011 (from port 0) during cycle 65 (325ns - 330ns)
*	Reading 00101100010100011100000011011010 from address 1111011 (from port 0) during cycle 66 (330ns - 335ns)
*	Writing 10110010100011100000000001001010  to  address 0000010 (from port 0) during cycle 67 (335ns - 340ns)
*	Writing 11011101111110000000111100101110  to  address 0000001 (from port 0) during cycle 68 (340ns - 345ns)
*	Reading 00101100010100011100000011011010 from address 1111011 (from port 0) during cycle 69 (345ns - 350ns)
*	Reading 10111001011001010010101100100110 from address 1111100 (from port 0) during cycle 74 (370ns - 375ns)
*	Writing 00100001100010010100111000110001  to  address 1111100 (from port 0) during cycle 75 (375ns - 380ns)
*	Reading 10111111111011010111100011101101 from address 1111110 (from port 0) during cycle 77 (385ns - 390ns)
*	Reading 01111100011000111011000011110000 from address 0000011 (from port 0) during cycle 79 (395ns - 400ns)
*	Reading 00101100010100011100000011011010 from address 1111011 (from port 0) during cycle 80 (400ns - 405ns)
*	Reading 01001110111111100001101111110011 from address 1111101 (from port 0) during cycle 81 (405ns - 410ns)
*	Writing 10010101000010000011010100110111  to  address 1111101 (from port 0) during cycle 82 (410ns - 415ns)
*	Writing 00000111100010011011111000011000  to  address 1111101 (from port 0) during cycle 83 (415ns - 420ns)
*	Reading 00101100010100011100000011011010 from address 1111011 (from port 0) during cycle 84 (420ns - 425ns)
*	Writing 00111111011111111111011000111110  to  address 1111100 (from port 0) during cycle 85 (425ns - 430ns)
*	Writing 01001000010100001000011110001100  to  address 1111101 (from port 0) during cycle 87 (435ns - 440ns)
*	Reading 01111100011000111011000011110000 from address 0000011 (from port 0) during cycle 88 (440ns - 445ns)
*	Reading 00111111011111111111011000111110 from address 1111100 (from port 0) during cycle 89 (445ns - 450ns)
*	Reading 11011101111110000000111100101110 from address 0000001 (from port 0) during cycle 90 (450ns - 455ns)
*	Writing 11111111111011111001110100100110  to  address 0000011 (from port 0) during cycle 92 (460ns - 465ns)
*	Reading 11111111111011111001110100100110 from address 0000011 (from port 0) during cycle 93 (465ns - 470ns)
*	Reading 00111111011111111111011000111110 from address 1111100 (from port 0) during cycle 94 (470ns - 475ns)
*	Reading 01001000010100001000011110001100 from address 1111101 (from port 0) during cycle 95 (475ns - 480ns)
*	Reading 10110010100011100000000001001010 from address 0000010 (from port 0) during cycle 96 (480ns - 485ns)
*	Writing 00100011101100100000010111111000  to  address 1111101 (from port 0) during cycle 97 (485ns - 490ns)
*	Reading 11011101111110000000111100101110 from address 0000001 (from port 0) during cycle 98 (490ns - 495ns)
*	Reading 00101100010100011100000011011010 from address 1111011 (from port 0) during cycle 99 (495ns - 500ns)
*	Reading 00111111011111111111011000111110 from address 1111100 (from port 0) during cycle 100 (500ns - 505ns)
*	Reading 00111111011111111111011000111110 from address 1111100 (from port 0) during cycle 102 (510ns - 515ns)
*	Reading 00111111011111111111011000111110 from address 1111100 (from port 0) during cycle 103 (515ns - 520ns)
*	Writing 01010101100010100111010101101101  to  address 0000011 (from port 0) during cycle 104 (520ns - 525ns)
*	Reading 01010101100010100111010101101101 from address 0000011 (from port 0) during cycle 105 (525ns - 530ns)
*	Reading 00111111011111111111011000111110 from address 1111100 (from port 0) during cycle 106 (530ns - 535ns)
*	Reading 10111111111011010111100011101101 from address 1111110 (from port 0) during cycle 107 (535ns - 540ns)
*	Reading 00101100010100011100000011011010 from address 1111011 (from port 0) during cycle 108 (540ns - 545ns)
*	Reading 01010101100010100111010101101101 from address 0000011 (from port 0) during cycle 109 (545ns - 550ns)
*	Reading 01010101100010100111010101101101 from address 0000011 (from port 0) during cycle 110 (550ns - 555ns)
*	Reading 11011101111110000000111100101110 from address 0000001 (from port 0) during cycle 111 (555ns - 560ns)
*	Reading 10110010100011100000000001001010 from address 0000010 (from port 0) during cycle 112 (560ns - 565ns)
*	Reading 01010101100010100111010101101101 from address 0000011 (from port 0) during cycle 113 (565ns - 570ns)
*	Reading 00100011101100100000010111111000 from address 1111101 (from port 0) during cycle 114 (570ns - 575ns)
*	Reading 00100011101100100000010111111000 from address 1111101 (from port 0) during cycle 115 (575ns - 580ns)
*	Reading 00100011101100100000010111111000 from address 1111101 (from port 0) during cycle 116 (580ns - 585ns)
*	Writing 11011000011100110000101010101001  to  address 1111110 (from port 0) during cycle 117 (585ns - 590ns)
*	Writing 00100011111110011111011011010111  to  address 0000000 (from port 0) during cycle 118 (590ns - 595ns)
*	Reading 00101100010100011100000011011010 from address 1111011 (from port 0) during cycle 119 (595ns - 600ns)
*	Writing 00001000000110100010011111000010  to  address 0000011 (from port 0) during cycle 120 (600ns - 605ns)
*	Reading 11011101111110000000111100101110 from address 0000001 (from port 0) during cycle 121 (605ns - 610ns)
*	Reading 00101100010100011100000011011010 from address 1111011 (from port 0) during cycle 123 (615ns - 620ns)
*	Reading 00111111011111111111011000111110 from address 1111100 (from port 0) during cycle 124 (620ns - 625ns)
*	Writing 11110101101001111000101101111000  to  address 0000000 (from port 0) during cycle 125 (625ns - 630ns)
*	Reading 10110010100011100000000001001010 from address 0000010 (from port 0) during cycle 126 (630ns - 635ns)
*	Writing 10010111010101010101011110010010  to  address 1111011 (from port 0) during cycle 127 (635ns - 640ns)
*	Writing 11100111010001100011010010111001  to  address 0000010 (from port 0) during cycle 129 (645ns - 650ns)
*	Reading 00111111011111111111011000111110 from address 1111100 (from port 0) during cycle 130 (650ns - 655ns)
*	Writing 11011010101010001111100011011101  to  address 0000011 (from port 0) during cycle 131 (655ns - 660ns)
*	Reading 11100111010001100011010010111001 from address 0000010 (from port 0) during cycle 132 (660ns - 665ns)
*	Reading 11011000011100110000101010101001 from address 1111110 (from port 0) during cycle 134 (670ns - 675ns)
*	Writing 11111001010111111111011000011100  to  address 0000001 (from port 0) during cycle 135 (675ns - 680ns)
*	Reading 11011010101010001111100011011101 from address 0000011 (from port 0) during cycle 137 (685ns - 690ns)
*	Reading 10010111010101010101011110010010 from address 1111011 (from port 0) during cycle 139 (695ns - 700ns)
*	Writing 01101110110101110010011110010001  to  address 0000001 (from port 0) during cycle 140 (700ns - 705ns)
*	Writing 11010011111110010111011110110100  to  address 0000000 (from port 0) during cycle 141 (705ns - 710ns)
*	Reading 11011000011100110000101010101001 from address 1111110 (from port 0) during cycle 142 (710ns - 715ns)
*	Reading 11010011111110010111011110110100 from address 0000000 (from port 0) during cycle 143 (715ns - 720ns)
*	Writing 00010110011110000110100011010111  to  address 0000001 (from port 0) during cycle 144 (720ns - 725ns)
*	Writing 01001110011111111101110111101101  to  address 0000010 (from port 0) during cycle 145 (725ns - 730ns)
*	Reading 11010011111110010111011110110100 from address 0000000 (from port 0) during cycle 146 (730ns - 735ns)
*	Writing 00111000101101100010101001011000  to  address 0000010 (from port 0) during cycle 147 (735ns - 740ns)
*	Reading 10010111010101010101011110010010 from address 1111011 (from port 0) during cycle 148 (740ns - 745ns)
*	Reading 00111111011111111111011000111110 from address 1111100 (from port 0) during cycle 149 (745ns - 750ns)
*	Writing 00011110110101010000000110011011  to  address 0000000 (from port 0) during cycle 150 (750ns - 755ns)
*	Writing 11111000001101011101110100010110  to  address 1111100 (from port 0) during cycle 151 (755ns - 760ns)
*	Reading 00100011101100100000010111111000 from address 1111101 (from port 0) during cycle 152 (760ns - 765ns)
*	Writing 11000101101101011011110111101100  to  address 0000001 (from port 0) during cycle 153 (765ns - 770ns)
*	Writing 11010110000101101000001101010111  to  address 0000010 (from port 0) during cycle 155 (775ns - 780ns)
*	Writing 10011001000100001000101100101001  to  address 0000001 (from port 0) during cycle 156 (780ns - 785ns)
*	Reading 00011110110101010000000110011011 from address 0000000 (from port 0) during cycle 157 (785ns - 790ns)
*	Writing 11000001100010101101000100000011  to  address 0000001 (from port 0) during cycle 158 (790ns - 795ns)
*	Writing 01111000100000111010110101001101  to  address 1111110 (from port 0) during cycle 159 (795ns - 800ns)
*	Reading 10010111010101010101011110010010 from address 1111011 (from port 0) during cycle 160 (800ns - 805ns)
*	Reading 00100011101100100000010111111000 from address 1111101 (from port 0) during cycle 161 (805ns - 810ns)
*	Reading 11000001100010101101000100000011 from address 0000001 (from port 0) during cycle 162 (810ns - 815ns)
*	Reading 11010110000101101000001101010111 from address 0000010 (from port 0) during cycle 163 (815ns - 820ns)
*	Writing 10000110001101110010111001010100  to  address 0000010 (from port 0) during cycle 164 (820ns - 825ns)
*	Reading 00100011101100100000010111111000 from address 1111101 (from port 0) during cycle 165 (825ns - 830ns)
*	Writing 00101100001001001101100000101001  to  address 1111100 (from port 0) during cycle 167 (835ns - 840ns)
*	Reading 00101100001001001101100000101001 from address 1111100 (from port 0) during cycle 168 (840ns - 845ns)
*	Reading 01111000100000111010110101001101 from address 1111110 (from port 0) during cycle 169 (845ns - 850ns)
*	Reading 11011010101010001111100011011101 from address 0000011 (from port 0) during cycle 171 (855ns - 860ns)
*	Writing 00110110001110101011110010011000  to  address 1111101 (from port 0) during cycle 173 (865ns - 870ns)
*	Reading 10010111010101010101011110010010 from address 1111011 (from port 0) during cycle 174 (870ns - 875ns)
*	Writing 01100100100011110111110101001001  to  address 0000000 (from port 0) during cycle 175 (875ns - 880ns)
*	Reading 10000110001101110010111001010100 from address 0000010 (from port 0) during cycle 176 (880ns - 885ns)
*	Reading 10010111010101010101011110010010 from address 1111011 (from port 0) during cycle 177 (885ns - 890ns)
*	Reading 01111000100000111010110101001101 from address 1111110 (from port 0) during cycle 178 (890ns - 895ns)
*	Reading 11011010101010001111100011011101 from address 0000011 (from port 0) during cycle 180 (900ns - 905ns)
*	Writing 11110001001110010010011110100101  to  address 1111011 (from port 0) during cycle 181 (905ns - 910ns)
*	Reading 01100100100011110111110101001001 from address 0000000 (from port 0) during cycle 182 (910ns - 915ns)
*	Reading 01111000100000111010110101001101 from address 1111110 (from port 0) during cycle 184 (920ns - 925ns)
*	Reading 11011010101010001111100011011101 from address 0000011 (from port 0) during cycle 185 (925ns - 930ns)
*	Reading 01100100100011110111110101001001 from address 0000000 (from port 0) during cycle 186 (930ns - 935ns)
*	Reading 00110110001110101011110010011000 from address 1111101 (from port 0) during cycle 187 (935ns - 940ns)
*	Reading 10000110001101110010111001010100 from address 0000010 (from port 0) during cycle 188 (940ns - 945ns)
*	Writing 10011010001000010000011011000101  to  address 1111101 (from port 0) during cycle 190 (950ns - 955ns)
*	Writing 11111100110001100011010100000001  to  address 0000010 (from port 0) during cycle 191 (955ns - 960ns)
*	Writing 01001011001110100101011111100110  to  address 0000000 (from port 0) during cycle 192 (960ns - 965ns)
*	Reading 11111100110001100011010100000001 from address 0000010 (from port 0) during cycle 193 (965ns - 970ns)
*	Reading 01111000100000111010110101001101 from address 1111110 (from port 0) during cycle 194 (970ns - 975ns)
*	Writing 10110001100000001010010000010110  to  address 0000000 (from port 0) during cycle 195 (975ns - 980ns)
*	Writing 00011110110110011010111001001001  to  address 0000011 (from port 0) during cycle 197 (985ns - 990ns)
*	Reading 10011010001000010000011011000101 from address 1111101 (from port 0) during cycle 199 (995ns - 1000ns)
*	Writing 01110110100110001110001011101001  to  address 0000011 (from port 0) during cycle 200 (1000ns - 1005ns)
*	Reading 11111100110001100011010100000001 from address 0000010 (from port 0) during cycle 201 (1005ns - 1010ns)
*	Reading 11111100110001100011010100000001 from address 0000010 (from port 0) during cycle 202 (1010ns - 1015ns)
*	Reading 01111000100000111010110101001101 from address 1111110 (from port 0) during cycle 203 (1015ns - 1020ns)
*	Reading 10110001100000001010010000010110 from address 0000000 (from port 0) during cycle 204 (1020ns - 1025ns)
*	Idle during cycle 205 (1025ns - 1030ns)

* Generation of data and address signals
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_0  din0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 1.1v 14.745n 1.1v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 1.1v 704.745n 1.1v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 1.1v 754.745n 1.1v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_1  din0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 1.1v 414.745n 1.1v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 1.1v 724.745n 1.1v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 1.1v 779.745n 1.1v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 1.1v 794.745n 1.1v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_2  din0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 1.1v 14.745n 1.1v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 1.1v 414.745n 1.1v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 0.0v 589.745n 0.0v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 0.0v 704.745n 0.0v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 0.0v 959.745n 0.0v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 1), (770, 1), (775, 0), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_3  din0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 0.0v 779.745n 0.0v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 0.0v 794.745n 0.0v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_4  din0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 1.1v 299.745n 1.1v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 1.1v 779.745n 1.1v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 0), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_5  din0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 0.0v 339.745n 0.0v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 0.0v 724.745n 0.0v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 0.0v 779.745n 0.0v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 0), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_6  din0_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 0.0v 589.745n 0.0v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 1.1v 954.745n 1.1v 954.755n 0.0v 959.745n 0.0v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_7  din0_7  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 1.1v 754.745n 1.1v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 0.0v 959.745n 0.0v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_8  din0_8  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 1.1v 414.745n 1.1v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 0.0v 724.745n 0.0v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 0.0v 954.745n 0.0v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_9  din0_9  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 0.0v 414.745n 0.0v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 0.0v 959.745n 0.0v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_10  din0_10  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 0.0v 589.745n 0.0v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 0.0v 724.745n 0.0v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_11  din0_11  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 0.0v 414.745n 0.0v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 0.0v 754.745n 0.0v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 0.0v 779.745n 0.0v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 0.0v 794.745n 0.0v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_12  din0_12  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 0.0v 589.745n 0.0v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 0.0v 704.745n 0.0v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 0.0v 724.745n 0.0v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 1.1v 794.745n 1.1v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 0), (965, 0), (970, 0), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_13  din0_13  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 0.0v 589.745n 0.0v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 0.0v 954.745n 0.0v 954.755n 1.1v 959.745n 1.1v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_14  din0_14  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 0.0v 589.745n 0.0v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 0.0v 704.745n 0.0v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 1.1v 794.745n 1.1v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_15  din0_15  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 1.1v 299.745n 1.1v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_16  din0_16  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 0.0v 414.745n 0.0v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 0.0v 724.745n 0.0v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_17  din0_17  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 1.1v 779.745n 1.1v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_18  din0_18  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 1.1v 339.745n 1.1v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 1.1v 959.745n 1.1v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_19  din0_19  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 0.0v 589.745n 0.0v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 0.0v 704.745n 0.0v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 1.1v 794.745n 1.1v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_20  din0_20  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 1.1v 299.745n 1.1v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 0), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_21  din0_21  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 0.0v 339.745n 0.0v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 0.0v 754.745n 0.0v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 0.0v 959.745n 0.0v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_22  din0_22  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 0.0v 339.745n 0.0v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 1.1v 589.745n 1.1v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 1.1v 754.745n 1.1v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 1.1v 959.745n 1.1v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 1), (420, 1), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 0), (760, 0), (765, 1), (770, 1), (775, 0), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 0), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_23  din0_23  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 0.0v 414.745n 0.0v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 0.0v 589.745n 0.0v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 1.1v 959.745n 1.1v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 1), (770, 1), (775, 0), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 1), (965, 1), (970, 1), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_24  din0_24  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 0.0v 589.745n 0.0v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 0.0v 704.745n 0.0v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 0.0v 779.745n 0.0v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 1), (710, 1), (715, 1), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 0), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_25  din0_25  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 1.1v 339.745n 1.1v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 1.1v 754.745n 1.1v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 1.1v 779.745n 1.1v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 1.1v 954.745n 1.1v 954.755n 0.0v 959.745n 0.0v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 1), (755, 0), (760, 0), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 0), (955, 1), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_26  din0_26  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 0.0v 339.745n 0.0v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 1.1v 704.745n 1.1v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 1.1v 724.745n 1.1v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 1.1v 754.745n 1.1v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 0.0v 954.745n 0.0v 954.755n 1.1v 959.745n 1.1v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 1), (255, 1), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 0), (595, 0), (600, 1), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 1), (730, 1), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 0), (910, 0), (915, 0), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 0), (950, 1), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_27  din0_27  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 0.0v 339.745n 0.0v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 0.0v 794.745n 0.0v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 0), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 1), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 1), (755, 1), (760, 1), (765, 0), (770, 0), (775, 1), (780, 1), (785, 1), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 1), (870, 1), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 1), (980, 1), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_28  din0_28  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 1.1v 414.745n 1.1v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 0.0v 704.745n 0.0v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 1.1v 724.745n 1.1v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 1.1v 754.745n 1.1v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 0.0v 794.745n 0.0v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 0), (375, 1), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 0), (425, 1), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 1), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 1), (595, 1), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 0), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 1), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 1), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 1), (870, 1), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 0), (965, 0), (970, 0), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_29  din0_29  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 0.0v 374.745n 0.0v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 1.1v 594.745n 1.1v 594.755n 1.1v 599.745n 1.1v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 0.0v 754.745n 0.0v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 0.0v 954.745n 0.0v 954.755n 1.1v 959.745n 1.1v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 0), (80, 0), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 0), (160, 0), (165, 0), (170, 0), (175, 0), (180, 0), (185, 0), (190, 0), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 1), (250, 1), (255, 1), (260, 0), (265, 0), (270, 0), (275, 0), (280, 0), (285, 0), (290, 0), (295, 0), (300, 0), (305, 0), (310, 0), (315, 0), (320, 0), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 0), (435, 1), (440, 1), (445, 1), (450, 1), (455, 1), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 0), (640, 0), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 1), (710, 1), (715, 1), (720, 0), (725, 1), (730, 1), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 0), (785, 0), (790, 1), (795, 1), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 0), (830, 0), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 1), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 1), (960, 1), (965, 1), (970, 1), (975, 0), (980, 0), (985, 0), (990, 0), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
Vdin0_30  din0_30  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 1.1v 249.745n 1.1v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 0.0v 339.745n 0.0v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 0.0v 724.745n 0.0v 724.755n 1.1v 729.745n 1.1v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 1.1v 794.745n 1.1v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 1.1v 879.745n 1.1v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 0.0v 954.745n 0.0v 954.755n 1.1v 959.745n 1.1v 959.755n 1.1v 964.745n 1.1v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 0), (135, 1), (140, 1), (145, 1), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 0), (250, 0), (255, 0), (260, 1), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 0), (335, 1), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 0), (385, 0), (390, 0), (395, 0), (400, 0), (405, 0), (410, 1), (415, 0), (420, 0), (425, 0), (430, 0), (435, 0), (440, 0), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 0), (495, 0), (500, 0), (505, 0), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 0), (625, 1), (630, 1), (635, 1), (640, 1), (645, 1), (650, 1), (655, 1), (660, 1), (665, 1), (670, 1), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 1), (710, 1), (715, 1), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 1), (760, 1), (765, 1), (770, 1), (775, 1), (780, 1), (785, 1), (790, 1), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 1), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 0), (860, 0), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 0), (900, 0), (905, 1), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 1), (955, 1), (960, 0), (965, 0), (970, 0), (975, 1), (980, 1), (985, 0), (990, 0), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Vdin0_31  din0_31  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 1.1v 264.745n 1.1v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 1.1v 339.745n 1.1v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 1.1v 414.745n 1.1v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 1.1v 629.745n 1.1v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 1.1v 654.745n 1.1v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 0.0v 704.745n 0.0v 704.755n 1.1v 709.745n 1.1v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 1.1v 779.745n 1.1v 779.755n 1.1v 784.745n 1.1v 784.755n 1.1v 789.745n 1.1v 789.755n 1.1v 794.745n 1.1v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 1.1v 824.745n 1.1v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 0.0v 904.745n 0.0v 904.755n 1.1v 909.745n 1.1v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 1.1v 954.745n 1.1v 954.755n 1.1v 959.745n 1.1v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 1.1v 979.745n 1.1v 979.755n 1.1v 984.745n 1.1v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 1), (50, 1), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 1), (130, 1), (135, 0), (140, 0), (145, 1), (150, 1), (155, 1), (160, 1), (165, 0), (170, 1), (175, 1), (180, 0), (185, 0), (190, 1), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 1), (260, 0), (265, 1), (270, 0), (275, 0), (280, 1), (285, 1), (290, 1), (295, 1), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 0), (340, 1), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 0), (390, 0), (395, 1), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 0), (430, 0), (435, 1), (440, 1), (445, 0), (450, 1), (455, 1), (460, 1), (465, 1), (470, 0), (475, 1), (480, 0), (485, 1), (490, 1), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 0), (535, 0), (540, 1), (545, 1), (550, 1), (555, 1), (560, 0), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 1), (600, 1), (605, 1), (610, 1), (615, 1), (620, 0), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 0), (655, 1), (660, 0), (665, 0), (670, 0), (675, 1), (680, 1), (685, 1), (690, 1), (695, 1), (700, 1), (705, 0), (710, 0), (715, 0), (720, 1), (725, 0), (730, 0), (735, 0), (740, 1), (745, 0), (750, 0), (755, 0), (760, 1), (765, 1), (770, 1), (775, 0), (780, 1), (785, 0), (790, 1), (795, 0), (800, 1), (805, 1), (810, 1), (815, 0), (820, 0), (825, 1), (830, 1), (835, 0), (840, 0), (845, 0), (850, 0), (855, 1), (860, 1), (865, 1), (870, 1), (875, 0), (880, 0), (885, 1), (890, 0), (895, 0), (900, 1), (905, 1), (910, 0), (915, 0), (920, 0), (925, 1), (930, 0), (935, 1), (940, 0), (945, 0), (950, 1), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 0), (985, 1), (990, 1), (995, 1), (1000, 1), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 0)]
Va0_0  a0_0  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 1.1v 49.745n 1.1v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 1.1v 149.745n 1.1v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 0.0v 169.745n 0.0v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 0.0v 184.745n 0.0v 184.755n 0.0v 189.745n 0.0v 189.755n 1.1v 194.745n 1.1v 194.755n 0.0v 199.745n 0.0v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 1.1v 249.745n 1.1v 249.755n 0.0v 254.745n 0.0v 254.755n 1.1v 259.745n 1.1v 259.755n 0.0v 264.745n 0.0v 264.755n 1.1v 269.745n 1.1v 269.755n 0.0v 274.745n 0.0v 274.755n 0.0v 279.745n 0.0v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 1.1v 299.745n 1.1v 299.755n 0.0v 304.745n 0.0v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 0.0v 339.745n 0.0v 339.755n 1.1v 344.745n 1.1v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 0.0v 389.745n 0.0v 389.755n 0.0v 394.745n 0.0v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 1.1v 439.745n 1.1v 439.755n 1.1v 444.745n 1.1v 444.755n 0.0v 449.745n 0.0v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 0.0v 474.745n 0.0v 474.755n 1.1v 479.745n 1.1v 479.755n 0.0v 484.745n 0.0v 484.755n 1.1v 489.745n 1.1v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 0.0v 564.745n 0.0v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 1.1v 659.745n 1.1v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 0.0v 674.745n 0.0v 674.755n 1.1v 679.745n 1.1v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 1.1v 704.745n 1.1v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 1.1v 724.745n 1.1v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 1.1v 744.745n 1.1v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 1.1v 764.745n 1.1v 764.755n 1.1v 769.745n 1.1v 769.755n 1.1v 774.745n 1.1v 774.755n 0.0v 779.745n 0.0v 779.755n 1.1v 784.745n 1.1v 784.755n 0.0v 789.745n 0.0v 789.755n 1.1v 794.745n 1.1v 794.755n 0.0v 799.745n 0.0v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 0.0v 854.745n 0.0v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 1.1v 889.745n 1.1v 889.755n 0.0v 894.745n 0.0v 894.755n 0.0v 899.745n 0.0v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 0.0v 924.745n 0.0v 924.755n 1.1v 929.745n 1.1v 929.755n 0.0v 934.745n 0.0v 934.755n 1.1v 939.745n 1.1v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 1.1v 954.745n 1.1v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 1.1v 1004.745n 1.1v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 0), (10, 1), (15, 1), (20, 1), (25, 0), (30, 0), (35, 0), (40, 0), (45, 0), (50, 0), (55, 0), (60, 0), (65, 0), (70, 0), (75, 1), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 0), (110, 1), (115, 0), (120, 0), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 1), (170, 0), (175, 0), (180, 1), (185, 1), (190, 0), (195, 1), (200, 1), (205, 1), (210, 1), (215, 1), (220, 1), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 0), (260, 0), (265, 0), (270, 1), (275, 1), (280, 0), (285, 0), (290, 0), (295, 1), (300, 1), (305, 0), (310, 1), (315, 1), (320, 1), (325, 1), (330, 1), (335, 1), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 0), (385, 1), (390, 1), (395, 1), (400, 1), (405, 0), (410, 0), (415, 0), (420, 1), (425, 0), (430, 0), (435, 0), (440, 1), (445, 0), (450, 0), (455, 0), (460, 1), (465, 1), (470, 0), (475, 0), (480, 1), (485, 0), (490, 0), (495, 1), (500, 0), (505, 0), (510, 0), (515, 0), (520, 1), (525, 1), (530, 0), (535, 1), (540, 1), (545, 1), (550, 1), (555, 0), (560, 1), (565, 1), (570, 0), (575, 0), (580, 0), (585, 1), (590, 0), (595, 1), (600, 1), (605, 0), (610, 0), (615, 1), (620, 0), (625, 0), (630, 1), (635, 1), (640, 1), (645, 1), (650, 0), (655, 1), (660, 1), (665, 1), (670, 1), (675, 0), (680, 0), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 0), (720, 0), (725, 1), (730, 0), (735, 1), (740, 1), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 0), (775, 1), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 0), (810, 0), (815, 1), (820, 1), (825, 0), (830, 0), (835, 0), (840, 0), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 1), (910, 0), (915, 0), (920, 1), (925, 1), (930, 0), (935, 0), (940, 1), (945, 1), (950, 0), (955, 1), (960, 0), (965, 1), (970, 1), (975, 0), (980, 0), (985, 1), (990, 1), (995, 0), (1000, 1), (1005, 1), (1010, 1), (1015, 1), (1020, 0), (1025, 0)]
Va0_1  a0_1  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 0.0v 9.745n 0.0v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 0.0v 39.745n 0.0v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 0.0v 69.745n 0.0v 69.755n 0.0v 74.745n 0.0v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 1.1v 114.745n 1.1v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 1.1v 169.745n 1.1v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 0.0v 194.745n 0.0v 194.755n 1.1v 199.745n 1.1v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 1.1v 224.745n 1.1v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 0.0v 249.745n 0.0v 249.755n 1.1v 254.745n 1.1v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 0.0v 309.745n 0.0v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 1.1v 329.745n 1.1v 329.755n 1.1v 334.745n 1.1v 334.755n 1.1v 339.745n 1.1v 339.755n 0.0v 344.745n 0.0v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 0.0v 384.745n 0.0v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 1.1v 424.745n 1.1v 424.755n 0.0v 429.745n 0.0v 429.755n 0.0v 434.745n 0.0v 434.755n 0.0v 439.745n 0.0v 439.755n 1.1v 444.745n 1.1v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 1.1v 464.745n 1.1v 464.755n 1.1v 469.745n 1.1v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 1.1v 499.745n 1.1v 499.755n 0.0v 504.745n 0.0v 504.755n 0.0v 509.745n 0.0v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 1.1v 524.745n 1.1v 524.755n 1.1v 529.745n 1.1v 529.755n 0.0v 534.745n 0.0v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 0.0v 559.745n 0.0v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 1.1v 599.745n 1.1v 599.755n 1.1v 604.745n 1.1v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 1.1v 619.745n 1.1v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 1.1v 634.745n 1.1v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 1.1v 649.745n 1.1v 649.755n 0.0v 654.745n 0.0v 654.755n 1.1v 659.745n 1.1v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 1.1v 714.745n 1.1v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 1.1v 729.745n 1.1v 729.755n 0.0v 734.745n 0.0v 734.755n 1.1v 739.745n 1.1v 739.755n 1.1v 744.745n 1.1v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 1.1v 779.745n 1.1v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 1.1v 819.745n 1.1v 819.755n 1.1v 824.745n 1.1v 824.755n 0.0v 829.745n 0.0v 829.755n 0.0v 834.745n 0.0v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 1.1v 874.745n 1.1v 874.755n 0.0v 879.745n 0.0v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 1.1v 909.745n 1.1v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 0.0v 954.745n 0.0v 954.755n 1.1v 959.745n 1.1v 959.755n 0.0v 964.745n 0.0v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 1.1v 989.745n 1.1v 989.755n 1.1v 994.745n 1.1v 994.755n 0.0v 999.745n 0.0v 999.755n 1.1v 1004.745n 1.1v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 0), (15, 0), (20, 0), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 0), (80, 0), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 0), (115, 0), (120, 1), (125, 0), (130, 0), (135, 1), (140, 1), (145, 0), (150, 0), (155, 0), (160, 0), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 0), (205, 0), (210, 0), (215, 0), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 0), (300, 1), (305, 1), (310, 0), (315, 0), (320, 0), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 0), (355, 0), (360, 0), (365, 0), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 0), (405, 1), (410, 1), (415, 1), (420, 0), (425, 1), (430, 1), (435, 1), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 1), (490, 0), (495, 0), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 1), (535, 1), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 0), (600, 0), (605, 0), (610, 0), (615, 0), (620, 1), (625, 0), (630, 0), (635, 0), (640, 0), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 0), (700, 0), (705, 0), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 1), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 0), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 0), (875, 0), (880, 0), (885, 0), (890, 1), (895, 1), (900, 0), (905, 0), (910, 0), (915, 0), (920, 1), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Va0_2  a0_2  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 0.0v 79.745n 0.0v 79.755n 0.0v 84.745n 0.0v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 1.1v 124.745n 1.1v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 1.1v 169.745n 1.1v 169.755n 0.0v 174.745n 0.0v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 0.0v 214.745n 0.0v 214.755n 0.0v 219.745n 0.0v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 1.1v 249.745n 1.1v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 1.1v 264.745n 1.1v 264.755n 0.0v 269.745n 0.0v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 0.0v 299.745n 0.0v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 0.0v 314.745n 0.0v 314.755n 0.0v 319.745n 0.0v 319.755n 0.0v 324.745n 0.0v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 0.0v 354.745n 0.0v 354.755n 0.0v 359.745n 0.0v 359.755n 0.0v 364.745n 0.0v 364.755n 0.0v 369.745n 0.0v 369.755n 1.1v 374.745n 1.1v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 0.0v 424.745n 0.0v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 0.0v 444.745n 0.0v 444.755n 1.1v 449.745n 1.1v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 0.0v 484.745n 0.0v 484.755n 1.1v 489.745n 1.1v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 0.0v 619.745n 0.0v 619.755n 1.1v 624.745n 1.1v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 0.0v 644.745n 0.0v 644.755n 0.0v 649.745n 0.0v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 1.1v 714.745n 1.1v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 1.1v 749.745n 1.1v 749.755n 0.0v 754.745n 0.0v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 1.1v 799.745n 1.1v 799.755n 0.0v 804.745n 0.0v 804.755n 1.1v 809.745n 1.1v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 1.1v 869.745n 1.1v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 1.1v 924.745n 1.1v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 1.1v 939.745n 1.1v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 1.1v 954.745n 1.1v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 1.1v 974.745n 1.1v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 1.1v 999.745n 1.1v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 1), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 1), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 1), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 1), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 1), (910, 0), (915, 0), (920, 1), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Va0_3  a0_3  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 1.1v 114.745n 1.1v 114.755n 0.0v 119.745n 0.0v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 1.1v 169.745n 1.1v 169.755n 0.0v 174.745n 0.0v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 0.0v 199.745n 0.0v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 1.1v 249.745n 1.1v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 1.1v 264.745n 1.1v 264.755n 0.0v 269.745n 0.0v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 1.1v 334.745n 1.1v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 0.0v 399.745n 0.0v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 0.0v 444.745n 0.0v 444.755n 1.1v 449.745n 1.1v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 0.0v 484.745n 0.0v 484.755n 1.1v 489.745n 1.1v 489.755n 0.0v 494.745n 0.0v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 1.1v 599.745n 1.1v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 0.0v 649.745n 0.0v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 1.1v 699.745n 1.1v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 1.1v 714.745n 1.1v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 0.0v 754.745n 0.0v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 1.1v 909.745n 1.1v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 1.1v 924.745n 1.1v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 1.1v 939.745n 1.1v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 1.1v 954.745n 1.1v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 1.1v 974.745n 1.1v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 1.1v 999.745n 1.1v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 1), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 1), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 1), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 1), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 1), (910, 0), (915, 0), (920, 1), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Va0_4  a0_4  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 1.1v 114.745n 1.1v 114.755n 0.0v 119.745n 0.0v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 1.1v 169.745n 1.1v 169.755n 0.0v 174.745n 0.0v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 0.0v 199.745n 0.0v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 1.1v 249.745n 1.1v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 1.1v 264.745n 1.1v 264.755n 0.0v 269.745n 0.0v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 1.1v 334.745n 1.1v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 0.0v 399.745n 0.0v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 0.0v 444.745n 0.0v 444.755n 1.1v 449.745n 1.1v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 0.0v 484.745n 0.0v 484.755n 1.1v 489.745n 1.1v 489.755n 0.0v 494.745n 0.0v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 1.1v 599.745n 1.1v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 0.0v 649.745n 0.0v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 1.1v 699.745n 1.1v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 1.1v 714.745n 1.1v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 0.0v 754.745n 0.0v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 1.1v 909.745n 1.1v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 1.1v 924.745n 1.1v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 1.1v 939.745n 1.1v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 1.1v 954.745n 1.1v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 1.1v 974.745n 1.1v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 1.1v 999.745n 1.1v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 1), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 1), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 1), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 1), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 1), (910, 0), (915, 0), (920, 1), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Va0_5  a0_5  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 1.1v 114.745n 1.1v 114.755n 0.0v 119.745n 0.0v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 1.1v 169.745n 1.1v 169.755n 0.0v 174.745n 0.0v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 0.0v 199.745n 0.0v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 1.1v 249.745n 1.1v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 1.1v 264.745n 1.1v 264.755n 0.0v 269.745n 0.0v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 1.1v 334.745n 1.1v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 0.0v 399.745n 0.0v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 0.0v 444.745n 0.0v 444.755n 1.1v 449.745n 1.1v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 0.0v 484.745n 0.0v 484.755n 1.1v 489.745n 1.1v 489.755n 0.0v 494.745n 0.0v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 1.1v 599.745n 1.1v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 0.0v 649.745n 0.0v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 1.1v 699.745n 1.1v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 1.1v 714.745n 1.1v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 0.0v 754.745n 0.0v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 1.1v 909.745n 1.1v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 1.1v 924.745n 1.1v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 1.1v 939.745n 1.1v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 1.1v 954.745n 1.1v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 1.1v 974.745n 1.1v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 1.1v 999.745n 1.1v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )
* (time, data): [(0, 0), (5, 1), (10, 1), (15, 1), (20, 1), (25, 1), (30, 1), (35, 1), (40, 1), (45, 0), (50, 0), (55, 1), (60, 1), (65, 1), (70, 1), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 0), (105, 0), (110, 1), (115, 0), (120, 1), (125, 1), (130, 1), (135, 1), (140, 1), (145, 1), (150, 0), (155, 0), (160, 0), (165, 1), (170, 0), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 0), (230, 0), (235, 0), (240, 0), (245, 1), (250, 0), (255, 0), (260, 1), (265, 0), (270, 1), (275, 1), (280, 1), (285, 0), (290, 0), (295, 1), (300, 1), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 1), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 1), (380, 1), (385, 1), (390, 1), (395, 0), (400, 1), (405, 1), (410, 1), (415, 1), (420, 1), (425, 1), (430, 1), (435, 1), (440, 0), (445, 1), (450, 0), (455, 0), (460, 0), (465, 0), (470, 1), (475, 1), (480, 0), (485, 1), (490, 0), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 0), (530, 1), (535, 1), (540, 1), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 1), (575, 1), (580, 1), (585, 1), (590, 0), (595, 1), (600, 0), (605, 0), (610, 0), (615, 1), (620, 1), (625, 0), (630, 0), (635, 1), (640, 1), (645, 0), (650, 1), (655, 0), (660, 0), (665, 0), (670, 1), (675, 0), (680, 0), (685, 0), (690, 0), (695, 1), (700, 0), (705, 0), (710, 1), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 1), (745, 1), (750, 0), (755, 1), (760, 1), (765, 0), (770, 0), (775, 0), (780, 0), (785, 0), (790, 0), (795, 1), (800, 1), (805, 1), (810, 0), (815, 0), (820, 0), (825, 1), (830, 1), (835, 1), (840, 1), (845, 1), (850, 1), (855, 0), (860, 0), (865, 1), (870, 1), (875, 0), (880, 0), (885, 1), (890, 1), (895, 1), (900, 0), (905, 1), (910, 0), (915, 0), (920, 1), (925, 0), (930, 0), (935, 1), (940, 0), (945, 0), (950, 1), (955, 0), (960, 0), (965, 0), (970, 1), (975, 0), (980, 0), (985, 0), (990, 0), (995, 1), (1000, 0), (1005, 0), (1010, 0), (1015, 1), (1020, 0), (1025, 0)]
Va0_6  a0_6  0 PWL (0n 0.0v 4.745n 0.0v 4.755n 1.1v 9.745n 1.1v 9.755n 1.1v 14.745n 1.1v 14.755n 1.1v 19.745n 1.1v 19.755n 1.1v 24.745n 1.1v 24.755n 1.1v 29.745n 1.1v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 0.0v 49.745n 0.0v 49.755n 0.0v 54.745n 0.0v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 1.1v 74.745n 1.1v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 0.0v 104.745n 0.0v 104.755n 0.0v 109.745n 0.0v 109.755n 1.1v 114.745n 1.1v 114.755n 0.0v 119.745n 0.0v 119.755n 1.1v 124.745n 1.1v 124.755n 1.1v 129.745n 1.1v 129.755n 1.1v 134.745n 1.1v 134.755n 1.1v 139.745n 1.1v 139.755n 1.1v 144.745n 1.1v 144.755n 1.1v 149.745n 1.1v 149.755n 0.0v 154.745n 0.0v 154.755n 0.0v 159.745n 0.0v 159.755n 0.0v 164.745n 0.0v 164.755n 1.1v 169.745n 1.1v 169.755n 0.0v 174.745n 0.0v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 0.0v 199.745n 0.0v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 0.0v 224.745n 0.0v 224.755n 0.0v 229.745n 0.0v 229.755n 0.0v 234.745n 0.0v 234.755n 0.0v 239.745n 0.0v 239.755n 0.0v 244.745n 0.0v 244.755n 1.1v 249.745n 1.1v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 1.1v 264.745n 1.1v 264.755n 0.0v 269.745n 0.0v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 0.0v 289.745n 0.0v 289.755n 0.0v 294.745n 0.0v 294.755n 1.1v 299.745n 1.1v 299.755n 1.1v 304.745n 1.1v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 1.1v 334.745n 1.1v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 1.1v 379.745n 1.1v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 0.0v 399.745n 0.0v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 1.1v 414.745n 1.1v 414.755n 1.1v 419.745n 1.1v 419.755n 1.1v 424.745n 1.1v 424.755n 1.1v 429.745n 1.1v 429.755n 1.1v 434.745n 1.1v 434.755n 1.1v 439.745n 1.1v 439.755n 0.0v 444.745n 0.0v 444.755n 1.1v 449.745n 1.1v 449.755n 0.0v 454.745n 0.0v 454.755n 0.0v 459.745n 0.0v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 0.0v 484.745n 0.0v 484.755n 1.1v 489.745n 1.1v 489.755n 0.0v 494.745n 0.0v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 1.1v 589.745n 1.1v 589.755n 0.0v 594.745n 0.0v 594.755n 1.1v 599.745n 1.1v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 0.0v 614.745n 0.0v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 1.1v 639.745n 1.1v 639.755n 1.1v 644.745n 1.1v 644.755n 0.0v 649.745n 0.0v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 0.0v 669.745n 0.0v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 0.0v 684.745n 0.0v 684.755n 0.0v 689.745n 0.0v 689.755n 0.0v 694.745n 0.0v 694.755n 1.1v 699.745n 1.1v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 1.1v 714.745n 1.1v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 0.0v 754.745n 0.0v 754.755n 1.1v 759.745n 1.1v 759.755n 1.1v 764.745n 1.1v 764.755n 0.0v 769.745n 0.0v 769.755n 0.0v 774.745n 0.0v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 1.1v 799.745n 1.1v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 1.1v 839.745n 1.1v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 0.0v 859.745n 0.0v 859.755n 0.0v 864.745n 0.0v 864.755n 1.1v 869.745n 1.1v 869.755n 1.1v 874.745n 1.1v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 1.1v 909.745n 1.1v 909.755n 0.0v 914.745n 0.0v 914.755n 0.0v 919.745n 0.0v 919.755n 1.1v 924.745n 1.1v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 1.1v 939.745n 1.1v 939.755n 0.0v 944.745n 0.0v 944.755n 0.0v 949.745n 0.0v 949.755n 1.1v 954.745n 1.1v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 1.1v 974.745n 1.1v 974.755n 0.0v 979.745n 0.0v 979.755n 0.0v 984.745n 0.0v 984.755n 0.0v 989.745n 0.0v 989.755n 0.0v 994.745n 0.0v 994.755n 1.1v 999.745n 1.1v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 0.0v )

 * Generation of control signals
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 0), (25, 0), (30, 0), (35, 1), (40, 0), (45, 0), (50, 1), (55, 0), (60, 0), (65, 1), (70, 0), (75, 0), (80, 1), (85, 0), (90, 0), (95, 0), (100, 0), (105, 1), (110, 0), (115, 0), (120, 0), (125, 0), (130, 0), (135, 0), (140, 0), (145, 0), (150, 0), (155, 1), (160, 1), (165, 0), (170, 0), (175, 0), (180, 0), (185, 1), (190, 0), (195, 0), (200, 0), (205, 0), (210, 1), (215, 1), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 0), (255, 0), (260, 0), (265, 0), (270, 0), (275, 1), (280, 0), (285, 0), (290, 1), (295, 0), (300, 0), (305, 0), (310, 0), (315, 1), (320, 1), (325, 0), (330, 0), (335, 0), (340, 0), (345, 0), (350, 1), (355, 1), (360, 1), (365, 1), (370, 0), (375, 0), (380, 1), (385, 0), (390, 1), (395, 0), (400, 0), (405, 0), (410, 0), (415, 0), (420, 0), (425, 0), (430, 1), (435, 0), (440, 0), (445, 0), (450, 0), (455, 1), (460, 0), (465, 0), (470, 0), (475, 0), (480, 0), (485, 0), (490, 0), (495, 0), (500, 0), (505, 1), (510, 0), (515, 0), (520, 0), (525, 0), (530, 0), (535, 0), (540, 0), (545, 0), (550, 0), (555, 0), (560, 0), (565, 0), (570, 0), (575, 0), (580, 0), (585, 0), (590, 0), (595, 0), (600, 0), (605, 0), (610, 1), (615, 0), (620, 0), (625, 0), (630, 0), (635, 0), (640, 1), (645, 0), (650, 0), (655, 0), (660, 0), (665, 1), (670, 0), (675, 0), (680, 1), (685, 0), (690, 1), (695, 0), (700, 0), (705, 0), (710, 0), (715, 0), (720, 0), (725, 0), (730, 0), (735, 0), (740, 0), (745, 0), (750, 0), (755, 0), (760, 0), (765, 0), (770, 1), (775, 0), (780, 0), (785, 0), (790, 0), (795, 0), (800, 0), (805, 0), (810, 0), (815, 0), (820, 0), (825, 0), (830, 1), (835, 0), (840, 0), (845, 0), (850, 1), (855, 0), (860, 1), (865, 0), (870, 0), (875, 0), (880, 0), (885, 0), (890, 0), (895, 1), (900, 0), (905, 0), (910, 0), (915, 1), (920, 0), (925, 0), (930, 0), (935, 0), (940, 0), (945, 1), (950, 0), (955, 0), (960, 0), (965, 0), (970, 0), (975, 0), (980, 1), (985, 0), (990, 1), (995, 0), (1000, 0), (1005, 0), (1010, 0), (1015, 0), (1020, 0), (1025, 1)]
VCSB0 CSB0 0 PWL (0n 1.1v 4.745n 1.1v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 0.0v 24.745n 0.0v 24.755n 0.0v 29.745n 0.0v 29.755n 0.0v 34.745n 0.0v 34.755n 1.1v 39.745n 1.1v 39.755n 0.0v 44.745n 0.0v 44.755n 0.0v 49.745n 0.0v 49.755n 1.1v 54.745n 1.1v 54.755n 0.0v 59.745n 0.0v 59.755n 0.0v 64.745n 0.0v 64.755n 1.1v 69.745n 1.1v 69.755n 0.0v 74.745n 0.0v 74.755n 0.0v 79.745n 0.0v 79.755n 1.1v 84.745n 1.1v 84.755n 0.0v 89.745n 0.0v 89.755n 0.0v 94.745n 0.0v 94.755n 0.0v 99.745n 0.0v 99.755n 0.0v 104.745n 0.0v 104.755n 1.1v 109.745n 1.1v 109.755n 0.0v 114.745n 0.0v 114.755n 0.0v 119.745n 0.0v 119.755n 0.0v 124.745n 0.0v 124.755n 0.0v 129.745n 0.0v 129.755n 0.0v 134.745n 0.0v 134.755n 0.0v 139.745n 0.0v 139.755n 0.0v 144.745n 0.0v 144.755n 0.0v 149.745n 0.0v 149.755n 0.0v 154.745n 0.0v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 0.0v 169.745n 0.0v 169.755n 0.0v 174.745n 0.0v 174.755n 0.0v 179.745n 0.0v 179.755n 0.0v 184.745n 0.0v 184.755n 1.1v 189.745n 1.1v 189.755n 0.0v 194.745n 0.0v 194.755n 0.0v 199.745n 0.0v 199.755n 0.0v 204.745n 0.0v 204.755n 0.0v 209.745n 0.0v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 0.0v 224.745n 0.0v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 0.0v 249.745n 0.0v 249.755n 0.0v 254.745n 0.0v 254.755n 0.0v 259.745n 0.0v 259.755n 0.0v 264.745n 0.0v 264.755n 0.0v 269.745n 0.0v 269.755n 0.0v 274.745n 0.0v 274.755n 1.1v 279.745n 1.1v 279.755n 0.0v 284.745n 0.0v 284.755n 0.0v 289.745n 0.0v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 0.0v 309.745n 0.0v 309.755n 0.0v 314.745n 0.0v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 0.0v 334.745n 0.0v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 0.0v 349.745n 0.0v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 0.0v 374.745n 0.0v 374.755n 0.0v 379.745n 0.0v 379.755n 1.1v 384.745n 1.1v 384.755n 0.0v 389.745n 0.0v 389.755n 1.1v 394.745n 1.1v 394.755n 0.0v 399.745n 0.0v 399.755n 0.0v 404.745n 0.0v 404.755n 0.0v 409.745n 0.0v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 0.0v 424.745n 0.0v 424.755n 0.0v 429.745n 0.0v 429.755n 1.1v 434.745n 1.1v 434.755n 0.0v 439.745n 0.0v 439.755n 0.0v 444.745n 0.0v 444.755n 0.0v 449.745n 0.0v 449.755n 0.0v 454.745n 0.0v 454.755n 1.1v 459.745n 1.1v 459.755n 0.0v 464.745n 0.0v 464.755n 0.0v 469.745n 0.0v 469.755n 0.0v 474.745n 0.0v 474.755n 0.0v 479.745n 0.0v 479.755n 0.0v 484.745n 0.0v 484.755n 0.0v 489.745n 0.0v 489.755n 0.0v 494.745n 0.0v 494.755n 0.0v 499.745n 0.0v 499.755n 0.0v 504.745n 0.0v 504.755n 1.1v 509.745n 1.1v 509.755n 0.0v 514.745n 0.0v 514.755n 0.0v 519.745n 0.0v 519.755n 0.0v 524.745n 0.0v 524.755n 0.0v 529.745n 0.0v 529.755n 0.0v 534.745n 0.0v 534.755n 0.0v 539.745n 0.0v 539.755n 0.0v 544.745n 0.0v 544.755n 0.0v 549.745n 0.0v 549.755n 0.0v 554.745n 0.0v 554.755n 0.0v 559.745n 0.0v 559.755n 0.0v 564.745n 0.0v 564.755n 0.0v 569.745n 0.0v 569.755n 0.0v 574.745n 0.0v 574.755n 0.0v 579.745n 0.0v 579.755n 0.0v 584.745n 0.0v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 0.0v 599.745n 0.0v 599.755n 0.0v 604.745n 0.0v 604.755n 0.0v 609.745n 0.0v 609.755n 1.1v 614.745n 1.1v 614.755n 0.0v 619.745n 0.0v 619.755n 0.0v 624.745n 0.0v 624.755n 0.0v 629.745n 0.0v 629.755n 0.0v 634.745n 0.0v 634.755n 0.0v 639.745n 0.0v 639.755n 1.1v 644.745n 1.1v 644.755n 0.0v 649.745n 0.0v 649.755n 0.0v 654.745n 0.0v 654.755n 0.0v 659.745n 0.0v 659.755n 0.0v 664.745n 0.0v 664.755n 1.1v 669.745n 1.1v 669.755n 0.0v 674.745n 0.0v 674.755n 0.0v 679.745n 0.0v 679.755n 1.1v 684.745n 1.1v 684.755n 0.0v 689.745n 0.0v 689.755n 1.1v 694.745n 1.1v 694.755n 0.0v 699.745n 0.0v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 0.0v 714.745n 0.0v 714.755n 0.0v 719.745n 0.0v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 0.0v 734.745n 0.0v 734.755n 0.0v 739.745n 0.0v 739.755n 0.0v 744.745n 0.0v 744.755n 0.0v 749.745n 0.0v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 0.0v 764.745n 0.0v 764.755n 0.0v 769.745n 0.0v 769.755n 1.1v 774.745n 1.1v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 0.0v 789.745n 0.0v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 0.0v 804.745n 0.0v 804.755n 0.0v 809.745n 0.0v 809.755n 0.0v 814.745n 0.0v 814.755n 0.0v 819.745n 0.0v 819.755n 0.0v 824.745n 0.0v 824.755n 0.0v 829.745n 0.0v 829.755n 1.1v 834.745n 1.1v 834.755n 0.0v 839.745n 0.0v 839.755n 0.0v 844.745n 0.0v 844.755n 0.0v 849.745n 0.0v 849.755n 1.1v 854.745n 1.1v 854.755n 0.0v 859.745n 0.0v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 0.0v 874.745n 0.0v 874.755n 0.0v 879.745n 0.0v 879.755n 0.0v 884.745n 0.0v 884.755n 0.0v 889.745n 0.0v 889.755n 0.0v 894.745n 0.0v 894.755n 1.1v 899.745n 1.1v 899.755n 0.0v 904.745n 0.0v 904.755n 0.0v 909.745n 0.0v 909.755n 0.0v 914.745n 0.0v 914.755n 1.1v 919.745n 1.1v 919.755n 0.0v 924.745n 0.0v 924.755n 0.0v 929.745n 0.0v 929.755n 0.0v 934.745n 0.0v 934.755n 0.0v 939.745n 0.0v 939.755n 0.0v 944.745n 0.0v 944.755n 1.1v 949.745n 1.1v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 0.0v 969.745n 0.0v 969.755n 0.0v 974.745n 0.0v 974.755n 0.0v 979.745n 0.0v 979.755n 1.1v 984.745n 1.1v 984.755n 0.0v 989.745n 0.0v 989.755n 1.1v 994.745n 1.1v 994.755n 0.0v 999.745n 0.0v 999.755n 0.0v 1004.745n 0.0v 1004.755n 0.0v 1009.745n 0.0v 1009.755n 0.0v 1014.745n 0.0v 1014.755n 0.0v 1019.745n 0.0v 1019.755n 0.0v 1024.745n 0.0v 1024.755n 1.1v )
* (time, data): [(0, 1), (5, 0), (10, 0), (15, 0), (20, 1), (25, 0), (30, 1), (35, 1), (40, 1), (45, 0), (50, 1), (55, 1), (60, 1), (65, 1), (70, 0), (75, 1), (80, 1), (85, 1), (90, 1), (95, 1), (100, 1), (105, 1), (110, 1), (115, 1), (120, 1), (125, 0), (130, 1), (135, 0), (140, 1), (145, 0), (150, 1), (155, 1), (160, 1), (165, 1), (170, 1), (175, 1), (180, 1), (185, 1), (190, 1), (195, 0), (200, 1), (205, 1), (210, 1), (215, 1), (220, 0), (225, 1), (230, 1), (235, 1), (240, 1), (245, 0), (250, 1), (255, 1), (260, 0), (265, 1), (270, 1), (275, 1), (280, 1), (285, 1), (290, 1), (295, 0), (300, 0), (305, 1), (310, 1), (315, 1), (320, 1), (325, 0), (330, 1), (335, 0), (340, 0), (345, 1), (350, 1), (355, 1), (360, 1), (365, 1), (370, 1), (375, 0), (380, 1), (385, 1), (390, 1), (395, 1), (400, 1), (405, 1), (410, 0), (415, 0), (420, 1), (425, 0), (430, 1), (435, 0), (440, 1), (445, 1), (450, 1), (455, 1), (460, 0), (465, 1), (470, 1), (475, 1), (480, 1), (485, 0), (490, 1), (495, 1), (500, 1), (505, 1), (510, 1), (515, 1), (520, 0), (525, 1), (530, 1), (535, 1), (540, 1), (545, 1), (550, 1), (555, 1), (560, 1), (565, 1), (570, 1), (575, 1), (580, 1), (585, 0), (590, 0), (595, 1), (600, 0), (605, 1), (610, 1), (615, 1), (620, 1), (625, 0), (630, 1), (635, 0), (640, 1), (645, 0), (650, 1), (655, 0), (660, 1), (665, 1), (670, 1), (675, 0), (680, 1), (685, 1), (690, 1), (695, 1), (700, 0), (705, 0), (710, 1), (715, 1), (720, 0), (725, 0), (730, 1), (735, 0), (740, 1), (745, 1), (750, 0), (755, 0), (760, 1), (765, 0), (770, 1), (775, 0), (780, 0), (785, 1), (790, 0), (795, 0), (800, 1), (805, 1), (810, 1), (815, 1), (820, 0), (825, 1), (830, 1), (835, 0), (840, 1), (845, 1), (850, 1), (855, 1), (860, 1), (865, 0), (870, 1), (875, 0), (880, 1), (885, 1), (890, 1), (895, 1), (900, 1), (905, 0), (910, 1), (915, 1), (920, 1), (925, 1), (930, 1), (935, 1), (940, 1), (945, 1), (950, 0), (955, 0), (960, 0), (965, 1), (970, 1), (975, 0), (980, 1), (985, 0), (990, 1), (995, 1), (1000, 0), (1005, 1), (1010, 1), (1015, 1), (1020, 1), (1025, 1)]
VWEB0 WEB0 0 PWL (0n 1.1v 4.745n 1.1v 4.755n 0.0v 9.745n 0.0v 9.755n 0.0v 14.745n 0.0v 14.755n 0.0v 19.745n 0.0v 19.755n 1.1v 24.745n 1.1v 24.755n 0.0v 29.745n 0.0v 29.755n 1.1v 34.745n 1.1v 34.755n 1.1v 39.745n 1.1v 39.755n 1.1v 44.745n 1.1v 44.755n 0.0v 49.745n 0.0v 49.755n 1.1v 54.745n 1.1v 54.755n 1.1v 59.745n 1.1v 59.755n 1.1v 64.745n 1.1v 64.755n 1.1v 69.745n 1.1v 69.755n 0.0v 74.745n 0.0v 74.755n 1.1v 79.745n 1.1v 79.755n 1.1v 84.745n 1.1v 84.755n 1.1v 89.745n 1.1v 89.755n 1.1v 94.745n 1.1v 94.755n 1.1v 99.745n 1.1v 99.755n 1.1v 104.745n 1.1v 104.755n 1.1v 109.745n 1.1v 109.755n 1.1v 114.745n 1.1v 114.755n 1.1v 119.745n 1.1v 119.755n 1.1v 124.745n 1.1v 124.755n 0.0v 129.745n 0.0v 129.755n 1.1v 134.745n 1.1v 134.755n 0.0v 139.745n 0.0v 139.755n 1.1v 144.745n 1.1v 144.755n 0.0v 149.745n 0.0v 149.755n 1.1v 154.745n 1.1v 154.755n 1.1v 159.745n 1.1v 159.755n 1.1v 164.745n 1.1v 164.755n 1.1v 169.745n 1.1v 169.755n 1.1v 174.745n 1.1v 174.755n 1.1v 179.745n 1.1v 179.755n 1.1v 184.745n 1.1v 184.755n 1.1v 189.745n 1.1v 189.755n 1.1v 194.745n 1.1v 194.755n 0.0v 199.745n 0.0v 199.755n 1.1v 204.745n 1.1v 204.755n 1.1v 209.745n 1.1v 209.755n 1.1v 214.745n 1.1v 214.755n 1.1v 219.745n 1.1v 219.755n 0.0v 224.745n 0.0v 224.755n 1.1v 229.745n 1.1v 229.755n 1.1v 234.745n 1.1v 234.755n 1.1v 239.745n 1.1v 239.755n 1.1v 244.745n 1.1v 244.755n 0.0v 249.745n 0.0v 249.755n 1.1v 254.745n 1.1v 254.755n 1.1v 259.745n 1.1v 259.755n 0.0v 264.745n 0.0v 264.755n 1.1v 269.745n 1.1v 269.755n 1.1v 274.745n 1.1v 274.755n 1.1v 279.745n 1.1v 279.755n 1.1v 284.745n 1.1v 284.755n 1.1v 289.745n 1.1v 289.755n 1.1v 294.745n 1.1v 294.755n 0.0v 299.745n 0.0v 299.755n 0.0v 304.745n 0.0v 304.755n 1.1v 309.745n 1.1v 309.755n 1.1v 314.745n 1.1v 314.755n 1.1v 319.745n 1.1v 319.755n 1.1v 324.745n 1.1v 324.755n 0.0v 329.745n 0.0v 329.755n 1.1v 334.745n 1.1v 334.755n 0.0v 339.745n 0.0v 339.755n 0.0v 344.745n 0.0v 344.755n 1.1v 349.745n 1.1v 349.755n 1.1v 354.745n 1.1v 354.755n 1.1v 359.745n 1.1v 359.755n 1.1v 364.745n 1.1v 364.755n 1.1v 369.745n 1.1v 369.755n 1.1v 374.745n 1.1v 374.755n 0.0v 379.745n 0.0v 379.755n 1.1v 384.745n 1.1v 384.755n 1.1v 389.745n 1.1v 389.755n 1.1v 394.745n 1.1v 394.755n 1.1v 399.745n 1.1v 399.755n 1.1v 404.745n 1.1v 404.755n 1.1v 409.745n 1.1v 409.755n 0.0v 414.745n 0.0v 414.755n 0.0v 419.745n 0.0v 419.755n 1.1v 424.745n 1.1v 424.755n 0.0v 429.745n 0.0v 429.755n 1.1v 434.745n 1.1v 434.755n 0.0v 439.745n 0.0v 439.755n 1.1v 444.745n 1.1v 444.755n 1.1v 449.745n 1.1v 449.755n 1.1v 454.745n 1.1v 454.755n 1.1v 459.745n 1.1v 459.755n 0.0v 464.745n 0.0v 464.755n 1.1v 469.745n 1.1v 469.755n 1.1v 474.745n 1.1v 474.755n 1.1v 479.745n 1.1v 479.755n 1.1v 484.745n 1.1v 484.755n 0.0v 489.745n 0.0v 489.755n 1.1v 494.745n 1.1v 494.755n 1.1v 499.745n 1.1v 499.755n 1.1v 504.745n 1.1v 504.755n 1.1v 509.745n 1.1v 509.755n 1.1v 514.745n 1.1v 514.755n 1.1v 519.745n 1.1v 519.755n 0.0v 524.745n 0.0v 524.755n 1.1v 529.745n 1.1v 529.755n 1.1v 534.745n 1.1v 534.755n 1.1v 539.745n 1.1v 539.755n 1.1v 544.745n 1.1v 544.755n 1.1v 549.745n 1.1v 549.755n 1.1v 554.745n 1.1v 554.755n 1.1v 559.745n 1.1v 559.755n 1.1v 564.745n 1.1v 564.755n 1.1v 569.745n 1.1v 569.755n 1.1v 574.745n 1.1v 574.755n 1.1v 579.745n 1.1v 579.755n 1.1v 584.745n 1.1v 584.755n 0.0v 589.745n 0.0v 589.755n 0.0v 594.745n 0.0v 594.755n 1.1v 599.745n 1.1v 599.755n 0.0v 604.745n 0.0v 604.755n 1.1v 609.745n 1.1v 609.755n 1.1v 614.745n 1.1v 614.755n 1.1v 619.745n 1.1v 619.755n 1.1v 624.745n 1.1v 624.755n 0.0v 629.745n 0.0v 629.755n 1.1v 634.745n 1.1v 634.755n 0.0v 639.745n 0.0v 639.755n 1.1v 644.745n 1.1v 644.755n 0.0v 649.745n 0.0v 649.755n 1.1v 654.745n 1.1v 654.755n 0.0v 659.745n 0.0v 659.755n 1.1v 664.745n 1.1v 664.755n 1.1v 669.745n 1.1v 669.755n 1.1v 674.745n 1.1v 674.755n 0.0v 679.745n 0.0v 679.755n 1.1v 684.745n 1.1v 684.755n 1.1v 689.745n 1.1v 689.755n 1.1v 694.745n 1.1v 694.755n 1.1v 699.745n 1.1v 699.755n 0.0v 704.745n 0.0v 704.755n 0.0v 709.745n 0.0v 709.755n 1.1v 714.745n 1.1v 714.755n 1.1v 719.745n 1.1v 719.755n 0.0v 724.745n 0.0v 724.755n 0.0v 729.745n 0.0v 729.755n 1.1v 734.745n 1.1v 734.755n 0.0v 739.745n 0.0v 739.755n 1.1v 744.745n 1.1v 744.755n 1.1v 749.745n 1.1v 749.755n 0.0v 754.745n 0.0v 754.755n 0.0v 759.745n 0.0v 759.755n 1.1v 764.745n 1.1v 764.755n 0.0v 769.745n 0.0v 769.755n 1.1v 774.745n 1.1v 774.755n 0.0v 779.745n 0.0v 779.755n 0.0v 784.745n 0.0v 784.755n 1.1v 789.745n 1.1v 789.755n 0.0v 794.745n 0.0v 794.755n 0.0v 799.745n 0.0v 799.755n 1.1v 804.745n 1.1v 804.755n 1.1v 809.745n 1.1v 809.755n 1.1v 814.745n 1.1v 814.755n 1.1v 819.745n 1.1v 819.755n 0.0v 824.745n 0.0v 824.755n 1.1v 829.745n 1.1v 829.755n 1.1v 834.745n 1.1v 834.755n 0.0v 839.745n 0.0v 839.755n 1.1v 844.745n 1.1v 844.755n 1.1v 849.745n 1.1v 849.755n 1.1v 854.745n 1.1v 854.755n 1.1v 859.745n 1.1v 859.755n 1.1v 864.745n 1.1v 864.755n 0.0v 869.745n 0.0v 869.755n 1.1v 874.745n 1.1v 874.755n 0.0v 879.745n 0.0v 879.755n 1.1v 884.745n 1.1v 884.755n 1.1v 889.745n 1.1v 889.755n 1.1v 894.745n 1.1v 894.755n 1.1v 899.745n 1.1v 899.755n 1.1v 904.745n 1.1v 904.755n 0.0v 909.745n 0.0v 909.755n 1.1v 914.745n 1.1v 914.755n 1.1v 919.745n 1.1v 919.755n 1.1v 924.745n 1.1v 924.755n 1.1v 929.745n 1.1v 929.755n 1.1v 934.745n 1.1v 934.755n 1.1v 939.745n 1.1v 939.755n 1.1v 944.745n 1.1v 944.755n 1.1v 949.745n 1.1v 949.755n 0.0v 954.745n 0.0v 954.755n 0.0v 959.745n 0.0v 959.755n 0.0v 964.745n 0.0v 964.755n 1.1v 969.745n 1.1v 969.755n 1.1v 974.745n 1.1v 974.755n 0.0v 979.745n 0.0v 979.755n 1.1v 984.745n 1.1v 984.755n 0.0v 989.745n 0.0v 989.755n 1.1v 994.745n 1.1v 994.755n 1.1v 999.745n 1.1v 999.755n 0.0v 1004.745n 0.0v 1004.755n 1.1v 1009.745n 1.1v 1009.755n 1.1v 1014.745n 1.1v 1014.755n 1.1v 1019.745n 1.1v 1019.755n 1.1v 1024.745n 1.1v 1024.755n 1.1v )
* PULSE: period=5
Vclk0 clk0 0 PULSE (0 1.1 4.995n 0.01n 0.01n 2.49n 5n)

 * Generation of dout measurements
* CHECK dout0_0 Vdout0_0ck4 = 0 time = 25
.meas tran vdout0_0ck4 FIND v(dout0_0) AT=25.025n

* CHECK dout0_1 Vdout0_1ck4 = 1.1 time = 25
.meas tran vdout0_1ck4 FIND v(dout0_1) AT=25.025n

* CHECK dout0_2 Vdout0_2ck4 = 0 time = 25
.meas tran vdout0_2ck4 FIND v(dout0_2) AT=25.025n

* CHECK dout0_3 Vdout0_3ck4 = 0 time = 25
.meas tran vdout0_3ck4 FIND v(dout0_3) AT=25.025n

* CHECK dout0_4 Vdout0_4ck4 = 1.1 time = 25
.meas tran vdout0_4ck4 FIND v(dout0_4) AT=25.025n

* CHECK dout0_5 Vdout0_5ck4 = 1.1 time = 25
.meas tran vdout0_5ck4 FIND v(dout0_5) AT=25.025n

* CHECK dout0_6 Vdout0_6ck4 = 0 time = 25
.meas tran vdout0_6ck4 FIND v(dout0_6) AT=25.025n

* CHECK dout0_7 Vdout0_7ck4 = 0 time = 25
.meas tran vdout0_7ck4 FIND v(dout0_7) AT=25.025n

* CHECK dout0_8 Vdout0_8ck4 = 1.1 time = 25
.meas tran vdout0_8ck4 FIND v(dout0_8) AT=25.025n

* CHECK dout0_9 Vdout0_9ck4 = 0 time = 25
.meas tran vdout0_9ck4 FIND v(dout0_9) AT=25.025n

* CHECK dout0_10 Vdout0_10ck4 = 0 time = 25
.meas tran vdout0_10ck4 FIND v(dout0_10) AT=25.025n

* CHECK dout0_11 Vdout0_11ck4 = 0 time = 25
.meas tran vdout0_11ck4 FIND v(dout0_11) AT=25.025n

* CHECK dout0_12 Vdout0_12ck4 = 1.1 time = 25
.meas tran vdout0_12ck4 FIND v(dout0_12) AT=25.025n

* CHECK dout0_13 Vdout0_13ck4 = 1.1 time = 25
.meas tran vdout0_13ck4 FIND v(dout0_13) AT=25.025n

* CHECK dout0_14 Vdout0_14ck4 = 1.1 time = 25
.meas tran vdout0_14ck4 FIND v(dout0_14) AT=25.025n

* CHECK dout0_15 Vdout0_15ck4 = 1.1 time = 25
.meas tran vdout0_15ck4 FIND v(dout0_15) AT=25.025n

* CHECK dout0_16 Vdout0_16ck4 = 0 time = 25
.meas tran vdout0_16ck4 FIND v(dout0_16) AT=25.025n

* CHECK dout0_17 Vdout0_17ck4 = 0 time = 25
.meas tran vdout0_17ck4 FIND v(dout0_17) AT=25.025n

* CHECK dout0_18 Vdout0_18ck4 = 1.1 time = 25
.meas tran vdout0_18ck4 FIND v(dout0_18) AT=25.025n

* CHECK dout0_19 Vdout0_19ck4 = 1.1 time = 25
.meas tran vdout0_19ck4 FIND v(dout0_19) AT=25.025n

* CHECK dout0_20 Vdout0_20ck4 = 1.1 time = 25
.meas tran vdout0_20ck4 FIND v(dout0_20) AT=25.025n

* CHECK dout0_21 Vdout0_21ck4 = 1.1 time = 25
.meas tran vdout0_21ck4 FIND v(dout0_21) AT=25.025n

* CHECK dout0_22 Vdout0_22ck4 = 1.1 time = 25
.meas tran vdout0_22ck4 FIND v(dout0_22) AT=25.025n

* CHECK dout0_23 Vdout0_23ck4 = 0 time = 25
.meas tran vdout0_23ck4 FIND v(dout0_23) AT=25.025n

* CHECK dout0_24 Vdout0_24ck4 = 0 time = 25
.meas tran vdout0_24ck4 FIND v(dout0_24) AT=25.025n

* CHECK dout0_25 Vdout0_25ck4 = 1.1 time = 25
.meas tran vdout0_25ck4 FIND v(dout0_25) AT=25.025n

* CHECK dout0_26 Vdout0_26ck4 = 1.1 time = 25
.meas tran vdout0_26ck4 FIND v(dout0_26) AT=25.025n

* CHECK dout0_27 Vdout0_27ck4 = 0 time = 25
.meas tran vdout0_27ck4 FIND v(dout0_27) AT=25.025n

* CHECK dout0_28 Vdout0_28ck4 = 1.1 time = 25
.meas tran vdout0_28ck4 FIND v(dout0_28) AT=25.025n

* CHECK dout0_29 Vdout0_29ck4 = 1.1 time = 25
.meas tran vdout0_29ck4 FIND v(dout0_29) AT=25.025n

* CHECK dout0_30 Vdout0_30ck4 = 0 time = 25
.meas tran vdout0_30ck4 FIND v(dout0_30) AT=25.025n

* CHECK dout0_31 Vdout0_31ck4 = 1.1 time = 25
.meas tran vdout0_31ck4 FIND v(dout0_31) AT=25.025n

* CHECK dout0_0 Vdout0_0ck6 = 1.1 time = 35
.meas tran vdout0_0ck6 FIND v(dout0_0) AT=35.025n

* CHECK dout0_1 Vdout0_1ck6 = 1.1 time = 35
.meas tran vdout0_1ck6 FIND v(dout0_1) AT=35.025n

* CHECK dout0_2 Vdout0_2ck6 = 1.1 time = 35
.meas tran vdout0_2ck6 FIND v(dout0_2) AT=35.025n

* CHECK dout0_3 Vdout0_3ck6 = 0 time = 35
.meas tran vdout0_3ck6 FIND v(dout0_3) AT=35.025n

* CHECK dout0_4 Vdout0_4ck6 = 0 time = 35
.meas tran vdout0_4ck6 FIND v(dout0_4) AT=35.025n

* CHECK dout0_5 Vdout0_5ck6 = 1.1 time = 35
.meas tran vdout0_5ck6 FIND v(dout0_5) AT=35.025n

* CHECK dout0_6 Vdout0_6ck6 = 0 time = 35
.meas tran vdout0_6ck6 FIND v(dout0_6) AT=35.025n

* CHECK dout0_7 Vdout0_7ck6 = 0 time = 35
.meas tran vdout0_7ck6 FIND v(dout0_7) AT=35.025n

* CHECK dout0_8 Vdout0_8ck6 = 0 time = 35
.meas tran vdout0_8ck6 FIND v(dout0_8) AT=35.025n

* CHECK dout0_9 Vdout0_9ck6 = 0 time = 35
.meas tran vdout0_9ck6 FIND v(dout0_9) AT=35.025n

* CHECK dout0_10 Vdout0_10ck6 = 0 time = 35
.meas tran vdout0_10ck6 FIND v(dout0_10) AT=35.025n

* CHECK dout0_11 Vdout0_11ck6 = 0 time = 35
.meas tran vdout0_11ck6 FIND v(dout0_11) AT=35.025n

* CHECK dout0_12 Vdout0_12ck6 = 0 time = 35
.meas tran vdout0_12ck6 FIND v(dout0_12) AT=35.025n

* CHECK dout0_13 Vdout0_13ck6 = 0 time = 35
.meas tran vdout0_13ck6 FIND v(dout0_13) AT=35.025n

* CHECK dout0_14 Vdout0_14ck6 = 0 time = 35
.meas tran vdout0_14ck6 FIND v(dout0_14) AT=35.025n

* CHECK dout0_15 Vdout0_15ck6 = 1.1 time = 35
.meas tran vdout0_15ck6 FIND v(dout0_15) AT=35.025n

* CHECK dout0_16 Vdout0_16ck6 = 1.1 time = 35
.meas tran vdout0_16ck6 FIND v(dout0_16) AT=35.025n

* CHECK dout0_17 Vdout0_17ck6 = 0 time = 35
.meas tran vdout0_17ck6 FIND v(dout0_17) AT=35.025n

* CHECK dout0_18 Vdout0_18ck6 = 1.1 time = 35
.meas tran vdout0_18ck6 FIND v(dout0_18) AT=35.025n

* CHECK dout0_19 Vdout0_19ck6 = 0 time = 35
.meas tran vdout0_19ck6 FIND v(dout0_19) AT=35.025n

* CHECK dout0_20 Vdout0_20ck6 = 0 time = 35
.meas tran vdout0_20ck6 FIND v(dout0_20) AT=35.025n

* CHECK dout0_21 Vdout0_21ck6 = 1.1 time = 35
.meas tran vdout0_21ck6 FIND v(dout0_21) AT=35.025n

* CHECK dout0_22 Vdout0_22ck6 = 0 time = 35
.meas tran vdout0_22ck6 FIND v(dout0_22) AT=35.025n

* CHECK dout0_23 Vdout0_23ck6 = 0 time = 35
.meas tran vdout0_23ck6 FIND v(dout0_23) AT=35.025n

* CHECK dout0_24 Vdout0_24ck6 = 0 time = 35
.meas tran vdout0_24ck6 FIND v(dout0_24) AT=35.025n

* CHECK dout0_25 Vdout0_25ck6 = 0 time = 35
.meas tran vdout0_25ck6 FIND v(dout0_25) AT=35.025n

* CHECK dout0_26 Vdout0_26ck6 = 1.1 time = 35
.meas tran vdout0_26ck6 FIND v(dout0_26) AT=35.025n

* CHECK dout0_27 Vdout0_27ck6 = 0 time = 35
.meas tran vdout0_27ck6 FIND v(dout0_27) AT=35.025n

* CHECK dout0_28 Vdout0_28ck6 = 1.1 time = 35
.meas tran vdout0_28ck6 FIND v(dout0_28) AT=35.025n

* CHECK dout0_29 Vdout0_29ck6 = 1.1 time = 35
.meas tran vdout0_29ck6 FIND v(dout0_29) AT=35.025n

* CHECK dout0_30 Vdout0_30ck6 = 1.1 time = 35
.meas tran vdout0_30ck6 FIND v(dout0_30) AT=35.025n

* CHECK dout0_31 Vdout0_31ck6 = 0 time = 35
.meas tran vdout0_31ck6 FIND v(dout0_31) AT=35.025n

* CHECK dout0_0 Vdout0_0ck8 = 1.1 time = 45
.meas tran vdout0_0ck8 FIND v(dout0_0) AT=45.025n

* CHECK dout0_1 Vdout0_1ck8 = 1.1 time = 45
.meas tran vdout0_1ck8 FIND v(dout0_1) AT=45.025n

* CHECK dout0_2 Vdout0_2ck8 = 1.1 time = 45
.meas tran vdout0_2ck8 FIND v(dout0_2) AT=45.025n

* CHECK dout0_3 Vdout0_3ck8 = 0 time = 45
.meas tran vdout0_3ck8 FIND v(dout0_3) AT=45.025n

* CHECK dout0_4 Vdout0_4ck8 = 0 time = 45
.meas tran vdout0_4ck8 FIND v(dout0_4) AT=45.025n

* CHECK dout0_5 Vdout0_5ck8 = 1.1 time = 45
.meas tran vdout0_5ck8 FIND v(dout0_5) AT=45.025n

* CHECK dout0_6 Vdout0_6ck8 = 0 time = 45
.meas tran vdout0_6ck8 FIND v(dout0_6) AT=45.025n

* CHECK dout0_7 Vdout0_7ck8 = 0 time = 45
.meas tran vdout0_7ck8 FIND v(dout0_7) AT=45.025n

* CHECK dout0_8 Vdout0_8ck8 = 0 time = 45
.meas tran vdout0_8ck8 FIND v(dout0_8) AT=45.025n

* CHECK dout0_9 Vdout0_9ck8 = 0 time = 45
.meas tran vdout0_9ck8 FIND v(dout0_9) AT=45.025n

* CHECK dout0_10 Vdout0_10ck8 = 0 time = 45
.meas tran vdout0_10ck8 FIND v(dout0_10) AT=45.025n

* CHECK dout0_11 Vdout0_11ck8 = 0 time = 45
.meas tran vdout0_11ck8 FIND v(dout0_11) AT=45.025n

* CHECK dout0_12 Vdout0_12ck8 = 0 time = 45
.meas tran vdout0_12ck8 FIND v(dout0_12) AT=45.025n

* CHECK dout0_13 Vdout0_13ck8 = 0 time = 45
.meas tran vdout0_13ck8 FIND v(dout0_13) AT=45.025n

* CHECK dout0_14 Vdout0_14ck8 = 0 time = 45
.meas tran vdout0_14ck8 FIND v(dout0_14) AT=45.025n

* CHECK dout0_15 Vdout0_15ck8 = 1.1 time = 45
.meas tran vdout0_15ck8 FIND v(dout0_15) AT=45.025n

* CHECK dout0_16 Vdout0_16ck8 = 1.1 time = 45
.meas tran vdout0_16ck8 FIND v(dout0_16) AT=45.025n

* CHECK dout0_17 Vdout0_17ck8 = 0 time = 45
.meas tran vdout0_17ck8 FIND v(dout0_17) AT=45.025n

* CHECK dout0_18 Vdout0_18ck8 = 1.1 time = 45
.meas tran vdout0_18ck8 FIND v(dout0_18) AT=45.025n

* CHECK dout0_19 Vdout0_19ck8 = 0 time = 45
.meas tran vdout0_19ck8 FIND v(dout0_19) AT=45.025n

* CHECK dout0_20 Vdout0_20ck8 = 0 time = 45
.meas tran vdout0_20ck8 FIND v(dout0_20) AT=45.025n

* CHECK dout0_21 Vdout0_21ck8 = 1.1 time = 45
.meas tran vdout0_21ck8 FIND v(dout0_21) AT=45.025n

* CHECK dout0_22 Vdout0_22ck8 = 0 time = 45
.meas tran vdout0_22ck8 FIND v(dout0_22) AT=45.025n

* CHECK dout0_23 Vdout0_23ck8 = 0 time = 45
.meas tran vdout0_23ck8 FIND v(dout0_23) AT=45.025n

* CHECK dout0_24 Vdout0_24ck8 = 0 time = 45
.meas tran vdout0_24ck8 FIND v(dout0_24) AT=45.025n

* CHECK dout0_25 Vdout0_25ck8 = 0 time = 45
.meas tran vdout0_25ck8 FIND v(dout0_25) AT=45.025n

* CHECK dout0_26 Vdout0_26ck8 = 1.1 time = 45
.meas tran vdout0_26ck8 FIND v(dout0_26) AT=45.025n

* CHECK dout0_27 Vdout0_27ck8 = 0 time = 45
.meas tran vdout0_27ck8 FIND v(dout0_27) AT=45.025n

* CHECK dout0_28 Vdout0_28ck8 = 1.1 time = 45
.meas tran vdout0_28ck8 FIND v(dout0_28) AT=45.025n

* CHECK dout0_29 Vdout0_29ck8 = 1.1 time = 45
.meas tran vdout0_29ck8 FIND v(dout0_29) AT=45.025n

* CHECK dout0_30 Vdout0_30ck8 = 1.1 time = 45
.meas tran vdout0_30ck8 FIND v(dout0_30) AT=45.025n

* CHECK dout0_31 Vdout0_31ck8 = 0 time = 45
.meas tran vdout0_31ck8 FIND v(dout0_31) AT=45.025n

* CHECK dout0_0 Vdout0_0ck11 = 1.1 time = 60
.meas tran vdout0_0ck11 FIND v(dout0_0) AT=60.025n

* CHECK dout0_1 Vdout0_1ck11 = 1.1 time = 60
.meas tran vdout0_1ck11 FIND v(dout0_1) AT=60.025n

* CHECK dout0_2 Vdout0_2ck11 = 1.1 time = 60
.meas tran vdout0_2ck11 FIND v(dout0_2) AT=60.025n

* CHECK dout0_3 Vdout0_3ck11 = 0 time = 60
.meas tran vdout0_3ck11 FIND v(dout0_3) AT=60.025n

* CHECK dout0_4 Vdout0_4ck11 = 0 time = 60
.meas tran vdout0_4ck11 FIND v(dout0_4) AT=60.025n

* CHECK dout0_5 Vdout0_5ck11 = 1.1 time = 60
.meas tran vdout0_5ck11 FIND v(dout0_5) AT=60.025n

* CHECK dout0_6 Vdout0_6ck11 = 0 time = 60
.meas tran vdout0_6ck11 FIND v(dout0_6) AT=60.025n

* CHECK dout0_7 Vdout0_7ck11 = 0 time = 60
.meas tran vdout0_7ck11 FIND v(dout0_7) AT=60.025n

* CHECK dout0_8 Vdout0_8ck11 = 0 time = 60
.meas tran vdout0_8ck11 FIND v(dout0_8) AT=60.025n

* CHECK dout0_9 Vdout0_9ck11 = 0 time = 60
.meas tran vdout0_9ck11 FIND v(dout0_9) AT=60.025n

* CHECK dout0_10 Vdout0_10ck11 = 0 time = 60
.meas tran vdout0_10ck11 FIND v(dout0_10) AT=60.025n

* CHECK dout0_11 Vdout0_11ck11 = 0 time = 60
.meas tran vdout0_11ck11 FIND v(dout0_11) AT=60.025n

* CHECK dout0_12 Vdout0_12ck11 = 0 time = 60
.meas tran vdout0_12ck11 FIND v(dout0_12) AT=60.025n

* CHECK dout0_13 Vdout0_13ck11 = 0 time = 60
.meas tran vdout0_13ck11 FIND v(dout0_13) AT=60.025n

* CHECK dout0_14 Vdout0_14ck11 = 0 time = 60
.meas tran vdout0_14ck11 FIND v(dout0_14) AT=60.025n

* CHECK dout0_15 Vdout0_15ck11 = 1.1 time = 60
.meas tran vdout0_15ck11 FIND v(dout0_15) AT=60.025n

* CHECK dout0_16 Vdout0_16ck11 = 1.1 time = 60
.meas tran vdout0_16ck11 FIND v(dout0_16) AT=60.025n

* CHECK dout0_17 Vdout0_17ck11 = 0 time = 60
.meas tran vdout0_17ck11 FIND v(dout0_17) AT=60.025n

* CHECK dout0_18 Vdout0_18ck11 = 1.1 time = 60
.meas tran vdout0_18ck11 FIND v(dout0_18) AT=60.025n

* CHECK dout0_19 Vdout0_19ck11 = 0 time = 60
.meas tran vdout0_19ck11 FIND v(dout0_19) AT=60.025n

* CHECK dout0_20 Vdout0_20ck11 = 0 time = 60
.meas tran vdout0_20ck11 FIND v(dout0_20) AT=60.025n

* CHECK dout0_21 Vdout0_21ck11 = 1.1 time = 60
.meas tran vdout0_21ck11 FIND v(dout0_21) AT=60.025n

* CHECK dout0_22 Vdout0_22ck11 = 0 time = 60
.meas tran vdout0_22ck11 FIND v(dout0_22) AT=60.025n

* CHECK dout0_23 Vdout0_23ck11 = 0 time = 60
.meas tran vdout0_23ck11 FIND v(dout0_23) AT=60.025n

* CHECK dout0_24 Vdout0_24ck11 = 0 time = 60
.meas tran vdout0_24ck11 FIND v(dout0_24) AT=60.025n

* CHECK dout0_25 Vdout0_25ck11 = 0 time = 60
.meas tran vdout0_25ck11 FIND v(dout0_25) AT=60.025n

* CHECK dout0_26 Vdout0_26ck11 = 1.1 time = 60
.meas tran vdout0_26ck11 FIND v(dout0_26) AT=60.025n

* CHECK dout0_27 Vdout0_27ck11 = 0 time = 60
.meas tran vdout0_27ck11 FIND v(dout0_27) AT=60.025n

* CHECK dout0_28 Vdout0_28ck11 = 1.1 time = 60
.meas tran vdout0_28ck11 FIND v(dout0_28) AT=60.025n

* CHECK dout0_29 Vdout0_29ck11 = 1.1 time = 60
.meas tran vdout0_29ck11 FIND v(dout0_29) AT=60.025n

* CHECK dout0_30 Vdout0_30ck11 = 1.1 time = 60
.meas tran vdout0_30ck11 FIND v(dout0_30) AT=60.025n

* CHECK dout0_31 Vdout0_31ck11 = 0 time = 60
.meas tran vdout0_31ck11 FIND v(dout0_31) AT=60.025n

* CHECK dout0_0 Vdout0_0ck12 = 1.1 time = 65
.meas tran vdout0_0ck12 FIND v(dout0_0) AT=65.025n

* CHECK dout0_1 Vdout0_1ck12 = 1.1 time = 65
.meas tran vdout0_1ck12 FIND v(dout0_1) AT=65.025n

* CHECK dout0_2 Vdout0_2ck12 = 1.1 time = 65
.meas tran vdout0_2ck12 FIND v(dout0_2) AT=65.025n

* CHECK dout0_3 Vdout0_3ck12 = 0 time = 65
.meas tran vdout0_3ck12 FIND v(dout0_3) AT=65.025n

* CHECK dout0_4 Vdout0_4ck12 = 0 time = 65
.meas tran vdout0_4ck12 FIND v(dout0_4) AT=65.025n

* CHECK dout0_5 Vdout0_5ck12 = 1.1 time = 65
.meas tran vdout0_5ck12 FIND v(dout0_5) AT=65.025n

* CHECK dout0_6 Vdout0_6ck12 = 0 time = 65
.meas tran vdout0_6ck12 FIND v(dout0_6) AT=65.025n

* CHECK dout0_7 Vdout0_7ck12 = 0 time = 65
.meas tran vdout0_7ck12 FIND v(dout0_7) AT=65.025n

* CHECK dout0_8 Vdout0_8ck12 = 0 time = 65
.meas tran vdout0_8ck12 FIND v(dout0_8) AT=65.025n

* CHECK dout0_9 Vdout0_9ck12 = 0 time = 65
.meas tran vdout0_9ck12 FIND v(dout0_9) AT=65.025n

* CHECK dout0_10 Vdout0_10ck12 = 0 time = 65
.meas tran vdout0_10ck12 FIND v(dout0_10) AT=65.025n

* CHECK dout0_11 Vdout0_11ck12 = 0 time = 65
.meas tran vdout0_11ck12 FIND v(dout0_11) AT=65.025n

* CHECK dout0_12 Vdout0_12ck12 = 0 time = 65
.meas tran vdout0_12ck12 FIND v(dout0_12) AT=65.025n

* CHECK dout0_13 Vdout0_13ck12 = 0 time = 65
.meas tran vdout0_13ck12 FIND v(dout0_13) AT=65.025n

* CHECK dout0_14 Vdout0_14ck12 = 0 time = 65
.meas tran vdout0_14ck12 FIND v(dout0_14) AT=65.025n

* CHECK dout0_15 Vdout0_15ck12 = 1.1 time = 65
.meas tran vdout0_15ck12 FIND v(dout0_15) AT=65.025n

* CHECK dout0_16 Vdout0_16ck12 = 1.1 time = 65
.meas tran vdout0_16ck12 FIND v(dout0_16) AT=65.025n

* CHECK dout0_17 Vdout0_17ck12 = 0 time = 65
.meas tran vdout0_17ck12 FIND v(dout0_17) AT=65.025n

* CHECK dout0_18 Vdout0_18ck12 = 1.1 time = 65
.meas tran vdout0_18ck12 FIND v(dout0_18) AT=65.025n

* CHECK dout0_19 Vdout0_19ck12 = 0 time = 65
.meas tran vdout0_19ck12 FIND v(dout0_19) AT=65.025n

* CHECK dout0_20 Vdout0_20ck12 = 0 time = 65
.meas tran vdout0_20ck12 FIND v(dout0_20) AT=65.025n

* CHECK dout0_21 Vdout0_21ck12 = 1.1 time = 65
.meas tran vdout0_21ck12 FIND v(dout0_21) AT=65.025n

* CHECK dout0_22 Vdout0_22ck12 = 0 time = 65
.meas tran vdout0_22ck12 FIND v(dout0_22) AT=65.025n

* CHECK dout0_23 Vdout0_23ck12 = 0 time = 65
.meas tran vdout0_23ck12 FIND v(dout0_23) AT=65.025n

* CHECK dout0_24 Vdout0_24ck12 = 0 time = 65
.meas tran vdout0_24ck12 FIND v(dout0_24) AT=65.025n

* CHECK dout0_25 Vdout0_25ck12 = 0 time = 65
.meas tran vdout0_25ck12 FIND v(dout0_25) AT=65.025n

* CHECK dout0_26 Vdout0_26ck12 = 1.1 time = 65
.meas tran vdout0_26ck12 FIND v(dout0_26) AT=65.025n

* CHECK dout0_27 Vdout0_27ck12 = 0 time = 65
.meas tran vdout0_27ck12 FIND v(dout0_27) AT=65.025n

* CHECK dout0_28 Vdout0_28ck12 = 1.1 time = 65
.meas tran vdout0_28ck12 FIND v(dout0_28) AT=65.025n

* CHECK dout0_29 Vdout0_29ck12 = 1.1 time = 65
.meas tran vdout0_29ck12 FIND v(dout0_29) AT=65.025n

* CHECK dout0_30 Vdout0_30ck12 = 1.1 time = 65
.meas tran vdout0_30ck12 FIND v(dout0_30) AT=65.025n

* CHECK dout0_31 Vdout0_31ck12 = 0 time = 65
.meas tran vdout0_31ck12 FIND v(dout0_31) AT=65.025n

* CHECK dout0_0 Vdout0_0ck15 = 0 time = 80
.meas tran vdout0_0ck15 FIND v(dout0_0) AT=80.025n

* CHECK dout0_1 Vdout0_1ck15 = 1.1 time = 80
.meas tran vdout0_1ck15 FIND v(dout0_1) AT=80.025n

* CHECK dout0_2 Vdout0_2ck15 = 0 time = 80
.meas tran vdout0_2ck15 FIND v(dout0_2) AT=80.025n

* CHECK dout0_3 Vdout0_3ck15 = 0 time = 80
.meas tran vdout0_3ck15 FIND v(dout0_3) AT=80.025n

* CHECK dout0_4 Vdout0_4ck15 = 1.1 time = 80
.meas tran vdout0_4ck15 FIND v(dout0_4) AT=80.025n

* CHECK dout0_5 Vdout0_5ck15 = 1.1 time = 80
.meas tran vdout0_5ck15 FIND v(dout0_5) AT=80.025n

* CHECK dout0_6 Vdout0_6ck15 = 0 time = 80
.meas tran vdout0_6ck15 FIND v(dout0_6) AT=80.025n

* CHECK dout0_7 Vdout0_7ck15 = 0 time = 80
.meas tran vdout0_7ck15 FIND v(dout0_7) AT=80.025n

* CHECK dout0_8 Vdout0_8ck15 = 1.1 time = 80
.meas tran vdout0_8ck15 FIND v(dout0_8) AT=80.025n

* CHECK dout0_9 Vdout0_9ck15 = 0 time = 80
.meas tran vdout0_9ck15 FIND v(dout0_9) AT=80.025n

* CHECK dout0_10 Vdout0_10ck15 = 0 time = 80
.meas tran vdout0_10ck15 FIND v(dout0_10) AT=80.025n

* CHECK dout0_11 Vdout0_11ck15 = 0 time = 80
.meas tran vdout0_11ck15 FIND v(dout0_11) AT=80.025n

* CHECK dout0_12 Vdout0_12ck15 = 1.1 time = 80
.meas tran vdout0_12ck15 FIND v(dout0_12) AT=80.025n

* CHECK dout0_13 Vdout0_13ck15 = 1.1 time = 80
.meas tran vdout0_13ck15 FIND v(dout0_13) AT=80.025n

* CHECK dout0_14 Vdout0_14ck15 = 1.1 time = 80
.meas tran vdout0_14ck15 FIND v(dout0_14) AT=80.025n

* CHECK dout0_15 Vdout0_15ck15 = 1.1 time = 80
.meas tran vdout0_15ck15 FIND v(dout0_15) AT=80.025n

* CHECK dout0_16 Vdout0_16ck15 = 0 time = 80
.meas tran vdout0_16ck15 FIND v(dout0_16) AT=80.025n

* CHECK dout0_17 Vdout0_17ck15 = 0 time = 80
.meas tran vdout0_17ck15 FIND v(dout0_17) AT=80.025n

* CHECK dout0_18 Vdout0_18ck15 = 1.1 time = 80
.meas tran vdout0_18ck15 FIND v(dout0_18) AT=80.025n

* CHECK dout0_19 Vdout0_19ck15 = 1.1 time = 80
.meas tran vdout0_19ck15 FIND v(dout0_19) AT=80.025n

* CHECK dout0_20 Vdout0_20ck15 = 1.1 time = 80
.meas tran vdout0_20ck15 FIND v(dout0_20) AT=80.025n

* CHECK dout0_21 Vdout0_21ck15 = 1.1 time = 80
.meas tran vdout0_21ck15 FIND v(dout0_21) AT=80.025n

* CHECK dout0_22 Vdout0_22ck15 = 1.1 time = 80
.meas tran vdout0_22ck15 FIND v(dout0_22) AT=80.025n

* CHECK dout0_23 Vdout0_23ck15 = 0 time = 80
.meas tran vdout0_23ck15 FIND v(dout0_23) AT=80.025n

* CHECK dout0_24 Vdout0_24ck15 = 0 time = 80
.meas tran vdout0_24ck15 FIND v(dout0_24) AT=80.025n

* CHECK dout0_25 Vdout0_25ck15 = 1.1 time = 80
.meas tran vdout0_25ck15 FIND v(dout0_25) AT=80.025n

* CHECK dout0_26 Vdout0_26ck15 = 1.1 time = 80
.meas tran vdout0_26ck15 FIND v(dout0_26) AT=80.025n

* CHECK dout0_27 Vdout0_27ck15 = 0 time = 80
.meas tran vdout0_27ck15 FIND v(dout0_27) AT=80.025n

* CHECK dout0_28 Vdout0_28ck15 = 1.1 time = 80
.meas tran vdout0_28ck15 FIND v(dout0_28) AT=80.025n

* CHECK dout0_29 Vdout0_29ck15 = 1.1 time = 80
.meas tran vdout0_29ck15 FIND v(dout0_29) AT=80.025n

* CHECK dout0_30 Vdout0_30ck15 = 0 time = 80
.meas tran vdout0_30ck15 FIND v(dout0_30) AT=80.025n

* CHECK dout0_31 Vdout0_31ck15 = 1.1 time = 80
.meas tran vdout0_31ck15 FIND v(dout0_31) AT=80.025n

* CHECK dout0_0 Vdout0_0ck17 = 0 time = 90
.meas tran vdout0_0ck17 FIND v(dout0_0) AT=90.025n

* CHECK dout0_1 Vdout0_1ck17 = 1.1 time = 90
.meas tran vdout0_1ck17 FIND v(dout0_1) AT=90.025n

* CHECK dout0_2 Vdout0_2ck17 = 0 time = 90
.meas tran vdout0_2ck17 FIND v(dout0_2) AT=90.025n

* CHECK dout0_3 Vdout0_3ck17 = 0 time = 90
.meas tran vdout0_3ck17 FIND v(dout0_3) AT=90.025n

* CHECK dout0_4 Vdout0_4ck17 = 1.1 time = 90
.meas tran vdout0_4ck17 FIND v(dout0_4) AT=90.025n

* CHECK dout0_5 Vdout0_5ck17 = 0 time = 90
.meas tran vdout0_5ck17 FIND v(dout0_5) AT=90.025n

* CHECK dout0_6 Vdout0_6ck17 = 0 time = 90
.meas tran vdout0_6ck17 FIND v(dout0_6) AT=90.025n

* CHECK dout0_7 Vdout0_7ck17 = 0 time = 90
.meas tran vdout0_7ck17 FIND v(dout0_7) AT=90.025n

* CHECK dout0_8 Vdout0_8ck17 = 1.1 time = 90
.meas tran vdout0_8ck17 FIND v(dout0_8) AT=90.025n

* CHECK dout0_9 Vdout0_9ck17 = 1.1 time = 90
.meas tran vdout0_9ck17 FIND v(dout0_9) AT=90.025n

* CHECK dout0_10 Vdout0_10ck17 = 1.1 time = 90
.meas tran vdout0_10ck17 FIND v(dout0_10) AT=90.025n

* CHECK dout0_11 Vdout0_11ck17 = 1.1 time = 90
.meas tran vdout0_11ck17 FIND v(dout0_11) AT=90.025n

* CHECK dout0_12 Vdout0_12ck17 = 1.1 time = 90
.meas tran vdout0_12ck17 FIND v(dout0_12) AT=90.025n

* CHECK dout0_13 Vdout0_13ck17 = 0 time = 90
.meas tran vdout0_13ck17 FIND v(dout0_13) AT=90.025n

* CHECK dout0_14 Vdout0_14ck17 = 1.1 time = 90
.meas tran vdout0_14ck17 FIND v(dout0_14) AT=90.025n

* CHECK dout0_15 Vdout0_15ck17 = 1.1 time = 90
.meas tran vdout0_15ck17 FIND v(dout0_15) AT=90.025n

* CHECK dout0_16 Vdout0_16ck17 = 0 time = 90
.meas tran vdout0_16ck17 FIND v(dout0_16) AT=90.025n

* CHECK dout0_17 Vdout0_17ck17 = 1.1 time = 90
.meas tran vdout0_17ck17 FIND v(dout0_17) AT=90.025n

* CHECK dout0_18 Vdout0_18ck17 = 0 time = 90
.meas tran vdout0_18ck17 FIND v(dout0_18) AT=90.025n

* CHECK dout0_19 Vdout0_19ck17 = 1.1 time = 90
.meas tran vdout0_19ck17 FIND v(dout0_19) AT=90.025n

* CHECK dout0_20 Vdout0_20ck17 = 0 time = 90
.meas tran vdout0_20ck17 FIND v(dout0_20) AT=90.025n

* CHECK dout0_21 Vdout0_21ck17 = 1.1 time = 90
.meas tran vdout0_21ck17 FIND v(dout0_21) AT=90.025n

* CHECK dout0_22 Vdout0_22ck17 = 1.1 time = 90
.meas tran vdout0_22ck17 FIND v(dout0_22) AT=90.025n

* CHECK dout0_23 Vdout0_23ck17 = 0 time = 90
.meas tran vdout0_23ck17 FIND v(dout0_23) AT=90.025n

* CHECK dout0_24 Vdout0_24ck17 = 1.1 time = 90
.meas tran vdout0_24ck17 FIND v(dout0_24) AT=90.025n

* CHECK dout0_25 Vdout0_25ck17 = 1.1 time = 90
.meas tran vdout0_25ck17 FIND v(dout0_25) AT=90.025n

* CHECK dout0_26 Vdout0_26ck17 = 0 time = 90
.meas tran vdout0_26ck17 FIND v(dout0_26) AT=90.025n

* CHECK dout0_27 Vdout0_27ck17 = 0 time = 90
.meas tran vdout0_27ck17 FIND v(dout0_27) AT=90.025n

* CHECK dout0_28 Vdout0_28ck17 = 1.1 time = 90
.meas tran vdout0_28ck17 FIND v(dout0_28) AT=90.025n

* CHECK dout0_29 Vdout0_29ck17 = 0 time = 90
.meas tran vdout0_29ck17 FIND v(dout0_29) AT=90.025n

* CHECK dout0_30 Vdout0_30ck17 = 0 time = 90
.meas tran vdout0_30ck17 FIND v(dout0_30) AT=90.025n

* CHECK dout0_31 Vdout0_31ck17 = 1.1 time = 90
.meas tran vdout0_31ck17 FIND v(dout0_31) AT=90.025n

* CHECK dout0_0 Vdout0_0ck18 = 0 time = 95
.meas tran vdout0_0ck18 FIND v(dout0_0) AT=95.025n

* CHECK dout0_1 Vdout0_1ck18 = 1.1 time = 95
.meas tran vdout0_1ck18 FIND v(dout0_1) AT=95.025n

* CHECK dout0_2 Vdout0_2ck18 = 0 time = 95
.meas tran vdout0_2ck18 FIND v(dout0_2) AT=95.025n

* CHECK dout0_3 Vdout0_3ck18 = 0 time = 95
.meas tran vdout0_3ck18 FIND v(dout0_3) AT=95.025n

* CHECK dout0_4 Vdout0_4ck18 = 1.1 time = 95
.meas tran vdout0_4ck18 FIND v(dout0_4) AT=95.025n

* CHECK dout0_5 Vdout0_5ck18 = 0 time = 95
.meas tran vdout0_5ck18 FIND v(dout0_5) AT=95.025n

* CHECK dout0_6 Vdout0_6ck18 = 0 time = 95
.meas tran vdout0_6ck18 FIND v(dout0_6) AT=95.025n

* CHECK dout0_7 Vdout0_7ck18 = 0 time = 95
.meas tran vdout0_7ck18 FIND v(dout0_7) AT=95.025n

* CHECK dout0_8 Vdout0_8ck18 = 1.1 time = 95
.meas tran vdout0_8ck18 FIND v(dout0_8) AT=95.025n

* CHECK dout0_9 Vdout0_9ck18 = 1.1 time = 95
.meas tran vdout0_9ck18 FIND v(dout0_9) AT=95.025n

* CHECK dout0_10 Vdout0_10ck18 = 1.1 time = 95
.meas tran vdout0_10ck18 FIND v(dout0_10) AT=95.025n

* CHECK dout0_11 Vdout0_11ck18 = 1.1 time = 95
.meas tran vdout0_11ck18 FIND v(dout0_11) AT=95.025n

* CHECK dout0_12 Vdout0_12ck18 = 1.1 time = 95
.meas tran vdout0_12ck18 FIND v(dout0_12) AT=95.025n

* CHECK dout0_13 Vdout0_13ck18 = 0 time = 95
.meas tran vdout0_13ck18 FIND v(dout0_13) AT=95.025n

* CHECK dout0_14 Vdout0_14ck18 = 1.1 time = 95
.meas tran vdout0_14ck18 FIND v(dout0_14) AT=95.025n

* CHECK dout0_15 Vdout0_15ck18 = 1.1 time = 95
.meas tran vdout0_15ck18 FIND v(dout0_15) AT=95.025n

* CHECK dout0_16 Vdout0_16ck18 = 0 time = 95
.meas tran vdout0_16ck18 FIND v(dout0_16) AT=95.025n

* CHECK dout0_17 Vdout0_17ck18 = 1.1 time = 95
.meas tran vdout0_17ck18 FIND v(dout0_17) AT=95.025n

* CHECK dout0_18 Vdout0_18ck18 = 0 time = 95
.meas tran vdout0_18ck18 FIND v(dout0_18) AT=95.025n

* CHECK dout0_19 Vdout0_19ck18 = 1.1 time = 95
.meas tran vdout0_19ck18 FIND v(dout0_19) AT=95.025n

* CHECK dout0_20 Vdout0_20ck18 = 0 time = 95
.meas tran vdout0_20ck18 FIND v(dout0_20) AT=95.025n

* CHECK dout0_21 Vdout0_21ck18 = 1.1 time = 95
.meas tran vdout0_21ck18 FIND v(dout0_21) AT=95.025n

* CHECK dout0_22 Vdout0_22ck18 = 1.1 time = 95
.meas tran vdout0_22ck18 FIND v(dout0_22) AT=95.025n

* CHECK dout0_23 Vdout0_23ck18 = 0 time = 95
.meas tran vdout0_23ck18 FIND v(dout0_23) AT=95.025n

* CHECK dout0_24 Vdout0_24ck18 = 1.1 time = 95
.meas tran vdout0_24ck18 FIND v(dout0_24) AT=95.025n

* CHECK dout0_25 Vdout0_25ck18 = 1.1 time = 95
.meas tran vdout0_25ck18 FIND v(dout0_25) AT=95.025n

* CHECK dout0_26 Vdout0_26ck18 = 0 time = 95
.meas tran vdout0_26ck18 FIND v(dout0_26) AT=95.025n

* CHECK dout0_27 Vdout0_27ck18 = 0 time = 95
.meas tran vdout0_27ck18 FIND v(dout0_27) AT=95.025n

* CHECK dout0_28 Vdout0_28ck18 = 1.1 time = 95
.meas tran vdout0_28ck18 FIND v(dout0_28) AT=95.025n

* CHECK dout0_29 Vdout0_29ck18 = 0 time = 95
.meas tran vdout0_29ck18 FIND v(dout0_29) AT=95.025n

* CHECK dout0_30 Vdout0_30ck18 = 0 time = 95
.meas tran vdout0_30ck18 FIND v(dout0_30) AT=95.025n

* CHECK dout0_31 Vdout0_31ck18 = 1.1 time = 95
.meas tran vdout0_31ck18 FIND v(dout0_31) AT=95.025n

* CHECK dout0_0 Vdout0_0ck19 = 0 time = 100
.meas tran vdout0_0ck19 FIND v(dout0_0) AT=100.025n

* CHECK dout0_1 Vdout0_1ck19 = 1.1 time = 100
.meas tran vdout0_1ck19 FIND v(dout0_1) AT=100.025n

* CHECK dout0_2 Vdout0_2ck19 = 0 time = 100
.meas tran vdout0_2ck19 FIND v(dout0_2) AT=100.025n

* CHECK dout0_3 Vdout0_3ck19 = 0 time = 100
.meas tran vdout0_3ck19 FIND v(dout0_3) AT=100.025n

* CHECK dout0_4 Vdout0_4ck19 = 1.1 time = 100
.meas tran vdout0_4ck19 FIND v(dout0_4) AT=100.025n

* CHECK dout0_5 Vdout0_5ck19 = 0 time = 100
.meas tran vdout0_5ck19 FIND v(dout0_5) AT=100.025n

* CHECK dout0_6 Vdout0_6ck19 = 0 time = 100
.meas tran vdout0_6ck19 FIND v(dout0_6) AT=100.025n

* CHECK dout0_7 Vdout0_7ck19 = 0 time = 100
.meas tran vdout0_7ck19 FIND v(dout0_7) AT=100.025n

* CHECK dout0_8 Vdout0_8ck19 = 1.1 time = 100
.meas tran vdout0_8ck19 FIND v(dout0_8) AT=100.025n

* CHECK dout0_9 Vdout0_9ck19 = 1.1 time = 100
.meas tran vdout0_9ck19 FIND v(dout0_9) AT=100.025n

* CHECK dout0_10 Vdout0_10ck19 = 1.1 time = 100
.meas tran vdout0_10ck19 FIND v(dout0_10) AT=100.025n

* CHECK dout0_11 Vdout0_11ck19 = 1.1 time = 100
.meas tran vdout0_11ck19 FIND v(dout0_11) AT=100.025n

* CHECK dout0_12 Vdout0_12ck19 = 1.1 time = 100
.meas tran vdout0_12ck19 FIND v(dout0_12) AT=100.025n

* CHECK dout0_13 Vdout0_13ck19 = 0 time = 100
.meas tran vdout0_13ck19 FIND v(dout0_13) AT=100.025n

* CHECK dout0_14 Vdout0_14ck19 = 1.1 time = 100
.meas tran vdout0_14ck19 FIND v(dout0_14) AT=100.025n

* CHECK dout0_15 Vdout0_15ck19 = 1.1 time = 100
.meas tran vdout0_15ck19 FIND v(dout0_15) AT=100.025n

* CHECK dout0_16 Vdout0_16ck19 = 0 time = 100
.meas tran vdout0_16ck19 FIND v(dout0_16) AT=100.025n

* CHECK dout0_17 Vdout0_17ck19 = 1.1 time = 100
.meas tran vdout0_17ck19 FIND v(dout0_17) AT=100.025n

* CHECK dout0_18 Vdout0_18ck19 = 0 time = 100
.meas tran vdout0_18ck19 FIND v(dout0_18) AT=100.025n

* CHECK dout0_19 Vdout0_19ck19 = 1.1 time = 100
.meas tran vdout0_19ck19 FIND v(dout0_19) AT=100.025n

* CHECK dout0_20 Vdout0_20ck19 = 0 time = 100
.meas tran vdout0_20ck19 FIND v(dout0_20) AT=100.025n

* CHECK dout0_21 Vdout0_21ck19 = 1.1 time = 100
.meas tran vdout0_21ck19 FIND v(dout0_21) AT=100.025n

* CHECK dout0_22 Vdout0_22ck19 = 1.1 time = 100
.meas tran vdout0_22ck19 FIND v(dout0_22) AT=100.025n

* CHECK dout0_23 Vdout0_23ck19 = 0 time = 100
.meas tran vdout0_23ck19 FIND v(dout0_23) AT=100.025n

* CHECK dout0_24 Vdout0_24ck19 = 1.1 time = 100
.meas tran vdout0_24ck19 FIND v(dout0_24) AT=100.025n

* CHECK dout0_25 Vdout0_25ck19 = 1.1 time = 100
.meas tran vdout0_25ck19 FIND v(dout0_25) AT=100.025n

* CHECK dout0_26 Vdout0_26ck19 = 0 time = 100
.meas tran vdout0_26ck19 FIND v(dout0_26) AT=100.025n

* CHECK dout0_27 Vdout0_27ck19 = 0 time = 100
.meas tran vdout0_27ck19 FIND v(dout0_27) AT=100.025n

* CHECK dout0_28 Vdout0_28ck19 = 1.1 time = 100
.meas tran vdout0_28ck19 FIND v(dout0_28) AT=100.025n

* CHECK dout0_29 Vdout0_29ck19 = 0 time = 100
.meas tran vdout0_29ck19 FIND v(dout0_29) AT=100.025n

* CHECK dout0_30 Vdout0_30ck19 = 0 time = 100
.meas tran vdout0_30ck19 FIND v(dout0_30) AT=100.025n

* CHECK dout0_31 Vdout0_31ck19 = 1.1 time = 100
.meas tran vdout0_31ck19 FIND v(dout0_31) AT=100.025n

* CHECK dout0_0 Vdout0_0ck20 = 1.1 time = 105
.meas tran vdout0_0ck20 FIND v(dout0_0) AT=105.025n

* CHECK dout0_1 Vdout0_1ck20 = 1.1 time = 105
.meas tran vdout0_1ck20 FIND v(dout0_1) AT=105.025n

* CHECK dout0_2 Vdout0_2ck20 = 0 time = 105
.meas tran vdout0_2ck20 FIND v(dout0_2) AT=105.025n

* CHECK dout0_3 Vdout0_3ck20 = 1.1 time = 105
.meas tran vdout0_3ck20 FIND v(dout0_3) AT=105.025n

* CHECK dout0_4 Vdout0_4ck20 = 0 time = 105
.meas tran vdout0_4ck20 FIND v(dout0_4) AT=105.025n

* CHECK dout0_5 Vdout0_5ck20 = 1.1 time = 105
.meas tran vdout0_5ck20 FIND v(dout0_5) AT=105.025n

* CHECK dout0_6 Vdout0_6ck20 = 0 time = 105
.meas tran vdout0_6ck20 FIND v(dout0_6) AT=105.025n

* CHECK dout0_7 Vdout0_7ck20 = 0 time = 105
.meas tran vdout0_7ck20 FIND v(dout0_7) AT=105.025n

* CHECK dout0_8 Vdout0_8ck20 = 0 time = 105
.meas tran vdout0_8ck20 FIND v(dout0_8) AT=105.025n

* CHECK dout0_9 Vdout0_9ck20 = 0 time = 105
.meas tran vdout0_9ck20 FIND v(dout0_9) AT=105.025n

* CHECK dout0_10 Vdout0_10ck20 = 0 time = 105
.meas tran vdout0_10ck20 FIND v(dout0_10) AT=105.025n

* CHECK dout0_11 Vdout0_11ck20 = 1.1 time = 105
.meas tran vdout0_11ck20 FIND v(dout0_11) AT=105.025n

* CHECK dout0_12 Vdout0_12ck20 = 1.1 time = 105
.meas tran vdout0_12ck20 FIND v(dout0_12) AT=105.025n

* CHECK dout0_13 Vdout0_13ck20 = 0 time = 105
.meas tran vdout0_13ck20 FIND v(dout0_13) AT=105.025n

* CHECK dout0_14 Vdout0_14ck20 = 0 time = 105
.meas tran vdout0_14ck20 FIND v(dout0_14) AT=105.025n

* CHECK dout0_15 Vdout0_15ck20 = 1.1 time = 105
.meas tran vdout0_15ck20 FIND v(dout0_15) AT=105.025n

* CHECK dout0_16 Vdout0_16ck20 = 1.1 time = 105
.meas tran vdout0_16ck20 FIND v(dout0_16) AT=105.025n

* CHECK dout0_17 Vdout0_17ck20 = 0 time = 105
.meas tran vdout0_17ck20 FIND v(dout0_17) AT=105.025n

* CHECK dout0_18 Vdout0_18ck20 = 0 time = 105
.meas tran vdout0_18ck20 FIND v(dout0_18) AT=105.025n

* CHECK dout0_19 Vdout0_19ck20 = 0 time = 105
.meas tran vdout0_19ck20 FIND v(dout0_19) AT=105.025n

* CHECK dout0_20 Vdout0_20ck20 = 1.1 time = 105
.meas tran vdout0_20ck20 FIND v(dout0_20) AT=105.025n

* CHECK dout0_21 Vdout0_21ck20 = 1.1 time = 105
.meas tran vdout0_21ck20 FIND v(dout0_21) AT=105.025n

* CHECK dout0_22 Vdout0_22ck20 = 0 time = 105
.meas tran vdout0_22ck20 FIND v(dout0_22) AT=105.025n

* CHECK dout0_23 Vdout0_23ck20 = 1.1 time = 105
.meas tran vdout0_23ck20 FIND v(dout0_23) AT=105.025n

* CHECK dout0_24 Vdout0_24ck20 = 0 time = 105
.meas tran vdout0_24ck20 FIND v(dout0_24) AT=105.025n

* CHECK dout0_25 Vdout0_25ck20 = 0 time = 105
.meas tran vdout0_25ck20 FIND v(dout0_25) AT=105.025n

* CHECK dout0_26 Vdout0_26ck20 = 0 time = 105
.meas tran vdout0_26ck20 FIND v(dout0_26) AT=105.025n

* CHECK dout0_27 Vdout0_27ck20 = 1.1 time = 105
.meas tran vdout0_27ck20 FIND v(dout0_27) AT=105.025n

* CHECK dout0_28 Vdout0_28ck20 = 1.1 time = 105
.meas tran vdout0_28ck20 FIND v(dout0_28) AT=105.025n

* CHECK dout0_29 Vdout0_29ck20 = 1.1 time = 105
.meas tran vdout0_29ck20 FIND v(dout0_29) AT=105.025n

* CHECK dout0_30 Vdout0_30ck20 = 1.1 time = 105
.meas tran vdout0_30ck20 FIND v(dout0_30) AT=105.025n

* CHECK dout0_31 Vdout0_31ck20 = 1.1 time = 105
.meas tran vdout0_31ck20 FIND v(dout0_31) AT=105.025n

* CHECK dout0_0 Vdout0_0ck22 = 0 time = 115
.meas tran vdout0_0ck22 FIND v(dout0_0) AT=115.025n

* CHECK dout0_1 Vdout0_1ck22 = 1.1 time = 115
.meas tran vdout0_1ck22 FIND v(dout0_1) AT=115.025n

* CHECK dout0_2 Vdout0_2ck22 = 0 time = 115
.meas tran vdout0_2ck22 FIND v(dout0_2) AT=115.025n

* CHECK dout0_3 Vdout0_3ck22 = 0 time = 115
.meas tran vdout0_3ck22 FIND v(dout0_3) AT=115.025n

* CHECK dout0_4 Vdout0_4ck22 = 1.1 time = 115
.meas tran vdout0_4ck22 FIND v(dout0_4) AT=115.025n

* CHECK dout0_5 Vdout0_5ck22 = 1.1 time = 115
.meas tran vdout0_5ck22 FIND v(dout0_5) AT=115.025n

* CHECK dout0_6 Vdout0_6ck22 = 0 time = 115
.meas tran vdout0_6ck22 FIND v(dout0_6) AT=115.025n

* CHECK dout0_7 Vdout0_7ck22 = 0 time = 115
.meas tran vdout0_7ck22 FIND v(dout0_7) AT=115.025n

* CHECK dout0_8 Vdout0_8ck22 = 1.1 time = 115
.meas tran vdout0_8ck22 FIND v(dout0_8) AT=115.025n

* CHECK dout0_9 Vdout0_9ck22 = 0 time = 115
.meas tran vdout0_9ck22 FIND v(dout0_9) AT=115.025n

* CHECK dout0_10 Vdout0_10ck22 = 0 time = 115
.meas tran vdout0_10ck22 FIND v(dout0_10) AT=115.025n

* CHECK dout0_11 Vdout0_11ck22 = 0 time = 115
.meas tran vdout0_11ck22 FIND v(dout0_11) AT=115.025n

* CHECK dout0_12 Vdout0_12ck22 = 1.1 time = 115
.meas tran vdout0_12ck22 FIND v(dout0_12) AT=115.025n

* CHECK dout0_13 Vdout0_13ck22 = 1.1 time = 115
.meas tran vdout0_13ck22 FIND v(dout0_13) AT=115.025n

* CHECK dout0_14 Vdout0_14ck22 = 1.1 time = 115
.meas tran vdout0_14ck22 FIND v(dout0_14) AT=115.025n

* CHECK dout0_15 Vdout0_15ck22 = 1.1 time = 115
.meas tran vdout0_15ck22 FIND v(dout0_15) AT=115.025n

* CHECK dout0_16 Vdout0_16ck22 = 0 time = 115
.meas tran vdout0_16ck22 FIND v(dout0_16) AT=115.025n

* CHECK dout0_17 Vdout0_17ck22 = 0 time = 115
.meas tran vdout0_17ck22 FIND v(dout0_17) AT=115.025n

* CHECK dout0_18 Vdout0_18ck22 = 1.1 time = 115
.meas tran vdout0_18ck22 FIND v(dout0_18) AT=115.025n

* CHECK dout0_19 Vdout0_19ck22 = 1.1 time = 115
.meas tran vdout0_19ck22 FIND v(dout0_19) AT=115.025n

* CHECK dout0_20 Vdout0_20ck22 = 1.1 time = 115
.meas tran vdout0_20ck22 FIND v(dout0_20) AT=115.025n

* CHECK dout0_21 Vdout0_21ck22 = 1.1 time = 115
.meas tran vdout0_21ck22 FIND v(dout0_21) AT=115.025n

* CHECK dout0_22 Vdout0_22ck22 = 1.1 time = 115
.meas tran vdout0_22ck22 FIND v(dout0_22) AT=115.025n

* CHECK dout0_23 Vdout0_23ck22 = 0 time = 115
.meas tran vdout0_23ck22 FIND v(dout0_23) AT=115.025n

* CHECK dout0_24 Vdout0_24ck22 = 0 time = 115
.meas tran vdout0_24ck22 FIND v(dout0_24) AT=115.025n

* CHECK dout0_25 Vdout0_25ck22 = 1.1 time = 115
.meas tran vdout0_25ck22 FIND v(dout0_25) AT=115.025n

* CHECK dout0_26 Vdout0_26ck22 = 1.1 time = 115
.meas tran vdout0_26ck22 FIND v(dout0_26) AT=115.025n

* CHECK dout0_27 Vdout0_27ck22 = 0 time = 115
.meas tran vdout0_27ck22 FIND v(dout0_27) AT=115.025n

* CHECK dout0_28 Vdout0_28ck22 = 1.1 time = 115
.meas tran vdout0_28ck22 FIND v(dout0_28) AT=115.025n

* CHECK dout0_29 Vdout0_29ck22 = 1.1 time = 115
.meas tran vdout0_29ck22 FIND v(dout0_29) AT=115.025n

* CHECK dout0_30 Vdout0_30ck22 = 0 time = 115
.meas tran vdout0_30ck22 FIND v(dout0_30) AT=115.025n

* CHECK dout0_31 Vdout0_31ck22 = 1.1 time = 115
.meas tran vdout0_31ck22 FIND v(dout0_31) AT=115.025n

* CHECK dout0_0 Vdout0_0ck23 = 1.1 time = 120
.meas tran vdout0_0ck23 FIND v(dout0_0) AT=120.025n

* CHECK dout0_1 Vdout0_1ck23 = 1.1 time = 120
.meas tran vdout0_1ck23 FIND v(dout0_1) AT=120.025n

* CHECK dout0_2 Vdout0_2ck23 = 0 time = 120
.meas tran vdout0_2ck23 FIND v(dout0_2) AT=120.025n

* CHECK dout0_3 Vdout0_3ck23 = 1.1 time = 120
.meas tran vdout0_3ck23 FIND v(dout0_3) AT=120.025n

* CHECK dout0_4 Vdout0_4ck23 = 0 time = 120
.meas tran vdout0_4ck23 FIND v(dout0_4) AT=120.025n

* CHECK dout0_5 Vdout0_5ck23 = 1.1 time = 120
.meas tran vdout0_5ck23 FIND v(dout0_5) AT=120.025n

* CHECK dout0_6 Vdout0_6ck23 = 0 time = 120
.meas tran vdout0_6ck23 FIND v(dout0_6) AT=120.025n

* CHECK dout0_7 Vdout0_7ck23 = 0 time = 120
.meas tran vdout0_7ck23 FIND v(dout0_7) AT=120.025n

* CHECK dout0_8 Vdout0_8ck23 = 0 time = 120
.meas tran vdout0_8ck23 FIND v(dout0_8) AT=120.025n

* CHECK dout0_9 Vdout0_9ck23 = 0 time = 120
.meas tran vdout0_9ck23 FIND v(dout0_9) AT=120.025n

* CHECK dout0_10 Vdout0_10ck23 = 0 time = 120
.meas tran vdout0_10ck23 FIND v(dout0_10) AT=120.025n

* CHECK dout0_11 Vdout0_11ck23 = 1.1 time = 120
.meas tran vdout0_11ck23 FIND v(dout0_11) AT=120.025n

* CHECK dout0_12 Vdout0_12ck23 = 1.1 time = 120
.meas tran vdout0_12ck23 FIND v(dout0_12) AT=120.025n

* CHECK dout0_13 Vdout0_13ck23 = 0 time = 120
.meas tran vdout0_13ck23 FIND v(dout0_13) AT=120.025n

* CHECK dout0_14 Vdout0_14ck23 = 0 time = 120
.meas tran vdout0_14ck23 FIND v(dout0_14) AT=120.025n

* CHECK dout0_15 Vdout0_15ck23 = 1.1 time = 120
.meas tran vdout0_15ck23 FIND v(dout0_15) AT=120.025n

* CHECK dout0_16 Vdout0_16ck23 = 1.1 time = 120
.meas tran vdout0_16ck23 FIND v(dout0_16) AT=120.025n

* CHECK dout0_17 Vdout0_17ck23 = 0 time = 120
.meas tran vdout0_17ck23 FIND v(dout0_17) AT=120.025n

* CHECK dout0_18 Vdout0_18ck23 = 0 time = 120
.meas tran vdout0_18ck23 FIND v(dout0_18) AT=120.025n

* CHECK dout0_19 Vdout0_19ck23 = 0 time = 120
.meas tran vdout0_19ck23 FIND v(dout0_19) AT=120.025n

* CHECK dout0_20 Vdout0_20ck23 = 1.1 time = 120
.meas tran vdout0_20ck23 FIND v(dout0_20) AT=120.025n

* CHECK dout0_21 Vdout0_21ck23 = 1.1 time = 120
.meas tran vdout0_21ck23 FIND v(dout0_21) AT=120.025n

* CHECK dout0_22 Vdout0_22ck23 = 0 time = 120
.meas tran vdout0_22ck23 FIND v(dout0_22) AT=120.025n

* CHECK dout0_23 Vdout0_23ck23 = 1.1 time = 120
.meas tran vdout0_23ck23 FIND v(dout0_23) AT=120.025n

* CHECK dout0_24 Vdout0_24ck23 = 0 time = 120
.meas tran vdout0_24ck23 FIND v(dout0_24) AT=120.025n

* CHECK dout0_25 Vdout0_25ck23 = 0 time = 120
.meas tran vdout0_25ck23 FIND v(dout0_25) AT=120.025n

* CHECK dout0_26 Vdout0_26ck23 = 0 time = 120
.meas tran vdout0_26ck23 FIND v(dout0_26) AT=120.025n

* CHECK dout0_27 Vdout0_27ck23 = 1.1 time = 120
.meas tran vdout0_27ck23 FIND v(dout0_27) AT=120.025n

* CHECK dout0_28 Vdout0_28ck23 = 1.1 time = 120
.meas tran vdout0_28ck23 FIND v(dout0_28) AT=120.025n

* CHECK dout0_29 Vdout0_29ck23 = 1.1 time = 120
.meas tran vdout0_29ck23 FIND v(dout0_29) AT=120.025n

* CHECK dout0_30 Vdout0_30ck23 = 1.1 time = 120
.meas tran vdout0_30ck23 FIND v(dout0_30) AT=120.025n

* CHECK dout0_31 Vdout0_31ck23 = 1.1 time = 120
.meas tran vdout0_31ck23 FIND v(dout0_31) AT=120.025n

* CHECK dout0_0 Vdout0_0ck24 = 0 time = 125
.meas tran vdout0_0ck24 FIND v(dout0_0) AT=125.025n

* CHECK dout0_1 Vdout0_1ck24 = 1.1 time = 125
.meas tran vdout0_1ck24 FIND v(dout0_1) AT=125.025n

* CHECK dout0_2 Vdout0_2ck24 = 0 time = 125
.meas tran vdout0_2ck24 FIND v(dout0_2) AT=125.025n

* CHECK dout0_3 Vdout0_3ck24 = 0 time = 125
.meas tran vdout0_3ck24 FIND v(dout0_3) AT=125.025n

* CHECK dout0_4 Vdout0_4ck24 = 1.1 time = 125
.meas tran vdout0_4ck24 FIND v(dout0_4) AT=125.025n

* CHECK dout0_5 Vdout0_5ck24 = 0 time = 125
.meas tran vdout0_5ck24 FIND v(dout0_5) AT=125.025n

* CHECK dout0_6 Vdout0_6ck24 = 0 time = 125
.meas tran vdout0_6ck24 FIND v(dout0_6) AT=125.025n

* CHECK dout0_7 Vdout0_7ck24 = 0 time = 125
.meas tran vdout0_7ck24 FIND v(dout0_7) AT=125.025n

* CHECK dout0_8 Vdout0_8ck24 = 1.1 time = 125
.meas tran vdout0_8ck24 FIND v(dout0_8) AT=125.025n

* CHECK dout0_9 Vdout0_9ck24 = 1.1 time = 125
.meas tran vdout0_9ck24 FIND v(dout0_9) AT=125.025n

* CHECK dout0_10 Vdout0_10ck24 = 1.1 time = 125
.meas tran vdout0_10ck24 FIND v(dout0_10) AT=125.025n

* CHECK dout0_11 Vdout0_11ck24 = 1.1 time = 125
.meas tran vdout0_11ck24 FIND v(dout0_11) AT=125.025n

* CHECK dout0_12 Vdout0_12ck24 = 1.1 time = 125
.meas tran vdout0_12ck24 FIND v(dout0_12) AT=125.025n

* CHECK dout0_13 Vdout0_13ck24 = 0 time = 125
.meas tran vdout0_13ck24 FIND v(dout0_13) AT=125.025n

* CHECK dout0_14 Vdout0_14ck24 = 1.1 time = 125
.meas tran vdout0_14ck24 FIND v(dout0_14) AT=125.025n

* CHECK dout0_15 Vdout0_15ck24 = 1.1 time = 125
.meas tran vdout0_15ck24 FIND v(dout0_15) AT=125.025n

* CHECK dout0_16 Vdout0_16ck24 = 0 time = 125
.meas tran vdout0_16ck24 FIND v(dout0_16) AT=125.025n

* CHECK dout0_17 Vdout0_17ck24 = 1.1 time = 125
.meas tran vdout0_17ck24 FIND v(dout0_17) AT=125.025n

* CHECK dout0_18 Vdout0_18ck24 = 0 time = 125
.meas tran vdout0_18ck24 FIND v(dout0_18) AT=125.025n

* CHECK dout0_19 Vdout0_19ck24 = 1.1 time = 125
.meas tran vdout0_19ck24 FIND v(dout0_19) AT=125.025n

* CHECK dout0_20 Vdout0_20ck24 = 0 time = 125
.meas tran vdout0_20ck24 FIND v(dout0_20) AT=125.025n

* CHECK dout0_21 Vdout0_21ck24 = 1.1 time = 125
.meas tran vdout0_21ck24 FIND v(dout0_21) AT=125.025n

* CHECK dout0_22 Vdout0_22ck24 = 1.1 time = 125
.meas tran vdout0_22ck24 FIND v(dout0_22) AT=125.025n

* CHECK dout0_23 Vdout0_23ck24 = 0 time = 125
.meas tran vdout0_23ck24 FIND v(dout0_23) AT=125.025n

* CHECK dout0_24 Vdout0_24ck24 = 1.1 time = 125
.meas tran vdout0_24ck24 FIND v(dout0_24) AT=125.025n

* CHECK dout0_25 Vdout0_25ck24 = 1.1 time = 125
.meas tran vdout0_25ck24 FIND v(dout0_25) AT=125.025n

* CHECK dout0_26 Vdout0_26ck24 = 0 time = 125
.meas tran vdout0_26ck24 FIND v(dout0_26) AT=125.025n

* CHECK dout0_27 Vdout0_27ck24 = 0 time = 125
.meas tran vdout0_27ck24 FIND v(dout0_27) AT=125.025n

* CHECK dout0_28 Vdout0_28ck24 = 1.1 time = 125
.meas tran vdout0_28ck24 FIND v(dout0_28) AT=125.025n

* CHECK dout0_29 Vdout0_29ck24 = 0 time = 125
.meas tran vdout0_29ck24 FIND v(dout0_29) AT=125.025n

* CHECK dout0_30 Vdout0_30ck24 = 0 time = 125
.meas tran vdout0_30ck24 FIND v(dout0_30) AT=125.025n

* CHECK dout0_31 Vdout0_31ck24 = 1.1 time = 125
.meas tran vdout0_31ck24 FIND v(dout0_31) AT=125.025n

* CHECK dout0_0 Vdout0_0ck26 = 1.1 time = 135
.meas tran vdout0_0ck26 FIND v(dout0_0) AT=135.025n

* CHECK dout0_1 Vdout0_1ck26 = 1.1 time = 135
.meas tran vdout0_1ck26 FIND v(dout0_1) AT=135.025n

* CHECK dout0_2 Vdout0_2ck26 = 0 time = 135
.meas tran vdout0_2ck26 FIND v(dout0_2) AT=135.025n

* CHECK dout0_3 Vdout0_3ck26 = 1.1 time = 135
.meas tran vdout0_3ck26 FIND v(dout0_3) AT=135.025n

* CHECK dout0_4 Vdout0_4ck26 = 1.1 time = 135
.meas tran vdout0_4ck26 FIND v(dout0_4) AT=135.025n

* CHECK dout0_5 Vdout0_5ck26 = 0 time = 135
.meas tran vdout0_5ck26 FIND v(dout0_5) AT=135.025n

* CHECK dout0_6 Vdout0_6ck26 = 1.1 time = 135
.meas tran vdout0_6ck26 FIND v(dout0_6) AT=135.025n

* CHECK dout0_7 Vdout0_7ck26 = 1.1 time = 135
.meas tran vdout0_7ck26 FIND v(dout0_7) AT=135.025n

* CHECK dout0_8 Vdout0_8ck26 = 0 time = 135
.meas tran vdout0_8ck26 FIND v(dout0_8) AT=135.025n

* CHECK dout0_9 Vdout0_9ck26 = 0 time = 135
.meas tran vdout0_9ck26 FIND v(dout0_9) AT=135.025n

* CHECK dout0_10 Vdout0_10ck26 = 1.1 time = 135
.meas tran vdout0_10ck26 FIND v(dout0_10) AT=135.025n

* CHECK dout0_11 Vdout0_11ck26 = 0 time = 135
.meas tran vdout0_11ck26 FIND v(dout0_11) AT=135.025n

* CHECK dout0_12 Vdout0_12ck26 = 1.1 time = 135
.meas tran vdout0_12ck26 FIND v(dout0_12) AT=135.025n

* CHECK dout0_13 Vdout0_13ck26 = 0 time = 135
.meas tran vdout0_13ck26 FIND v(dout0_13) AT=135.025n

* CHECK dout0_14 Vdout0_14ck26 = 1.1 time = 135
.meas tran vdout0_14ck26 FIND v(dout0_14) AT=135.025n

* CHECK dout0_15 Vdout0_15ck26 = 0 time = 135
.meas tran vdout0_15ck26 FIND v(dout0_15) AT=135.025n

* CHECK dout0_16 Vdout0_16ck26 = 1.1 time = 135
.meas tran vdout0_16ck26 FIND v(dout0_16) AT=135.025n

* CHECK dout0_17 Vdout0_17ck26 = 0 time = 135
.meas tran vdout0_17ck26 FIND v(dout0_17) AT=135.025n

* CHECK dout0_18 Vdout0_18ck26 = 1.1 time = 135
.meas tran vdout0_18ck26 FIND v(dout0_18) AT=135.025n

* CHECK dout0_19 Vdout0_19ck26 = 0 time = 135
.meas tran vdout0_19ck26 FIND v(dout0_19) AT=135.025n

* CHECK dout0_20 Vdout0_20ck26 = 1.1 time = 135
.meas tran vdout0_20ck26 FIND v(dout0_20) AT=135.025n

* CHECK dout0_21 Vdout0_21ck26 = 1.1 time = 135
.meas tran vdout0_21ck26 FIND v(dout0_21) AT=135.025n

* CHECK dout0_22 Vdout0_22ck26 = 1.1 time = 135
.meas tran vdout0_22ck26 FIND v(dout0_22) AT=135.025n

* CHECK dout0_23 Vdout0_23ck26 = 1.1 time = 135
.meas tran vdout0_23ck26 FIND v(dout0_23) AT=135.025n

* CHECK dout0_24 Vdout0_24ck26 = 1.1 time = 135
.meas tran vdout0_24ck26 FIND v(dout0_24) AT=135.025n

* CHECK dout0_25 Vdout0_25ck26 = 1.1 time = 135
.meas tran vdout0_25ck26 FIND v(dout0_25) AT=135.025n

* CHECK dout0_26 Vdout0_26ck26 = 1.1 time = 135
.meas tran vdout0_26ck26 FIND v(dout0_26) AT=135.025n

* CHECK dout0_27 Vdout0_27ck26 = 0 time = 135
.meas tran vdout0_27ck26 FIND v(dout0_27) AT=135.025n

* CHECK dout0_28 Vdout0_28ck26 = 1.1 time = 135
.meas tran vdout0_28ck26 FIND v(dout0_28) AT=135.025n

* CHECK dout0_29 Vdout0_29ck26 = 0 time = 135
.meas tran vdout0_29ck26 FIND v(dout0_29) AT=135.025n

* CHECK dout0_30 Vdout0_30ck26 = 0 time = 135
.meas tran vdout0_30ck26 FIND v(dout0_30) AT=135.025n

* CHECK dout0_31 Vdout0_31ck26 = 0 time = 135
.meas tran vdout0_31ck26 FIND v(dout0_31) AT=135.025n

* CHECK dout0_0 Vdout0_0ck28 = 1.1 time = 145
.meas tran vdout0_0ck28 FIND v(dout0_0) AT=145.025n

* CHECK dout0_1 Vdout0_1ck28 = 0 time = 145
.meas tran vdout0_1ck28 FIND v(dout0_1) AT=145.025n

* CHECK dout0_2 Vdout0_2ck28 = 0 time = 145
.meas tran vdout0_2ck28 FIND v(dout0_2) AT=145.025n

* CHECK dout0_3 Vdout0_3ck28 = 1.1 time = 145
.meas tran vdout0_3ck28 FIND v(dout0_3) AT=145.025n

* CHECK dout0_4 Vdout0_4ck28 = 1.1 time = 145
.meas tran vdout0_4ck28 FIND v(dout0_4) AT=145.025n

* CHECK dout0_5 Vdout0_5ck28 = 1.1 time = 145
.meas tran vdout0_5ck28 FIND v(dout0_5) AT=145.025n

* CHECK dout0_6 Vdout0_6ck28 = 1.1 time = 145
.meas tran vdout0_6ck28 FIND v(dout0_6) AT=145.025n

* CHECK dout0_7 Vdout0_7ck28 = 0 time = 145
.meas tran vdout0_7ck28 FIND v(dout0_7) AT=145.025n

* CHECK dout0_8 Vdout0_8ck28 = 0 time = 145
.meas tran vdout0_8ck28 FIND v(dout0_8) AT=145.025n

* CHECK dout0_9 Vdout0_9ck28 = 0 time = 145
.meas tran vdout0_9ck28 FIND v(dout0_9) AT=145.025n

* CHECK dout0_10 Vdout0_10ck28 = 1.1 time = 145
.meas tran vdout0_10ck28 FIND v(dout0_10) AT=145.025n

* CHECK dout0_11 Vdout0_11ck28 = 1.1 time = 145
.meas tran vdout0_11ck28 FIND v(dout0_11) AT=145.025n

* CHECK dout0_12 Vdout0_12ck28 = 1.1 time = 145
.meas tran vdout0_12ck28 FIND v(dout0_12) AT=145.025n

* CHECK dout0_13 Vdout0_13ck28 = 1.1 time = 145
.meas tran vdout0_13ck28 FIND v(dout0_13) AT=145.025n

* CHECK dout0_14 Vdout0_14ck28 = 1.1 time = 145
.meas tran vdout0_14ck28 FIND v(dout0_14) AT=145.025n

* CHECK dout0_15 Vdout0_15ck28 = 0 time = 145
.meas tran vdout0_15ck28 FIND v(dout0_15) AT=145.025n

* CHECK dout0_16 Vdout0_16ck28 = 0 time = 145
.meas tran vdout0_16ck28 FIND v(dout0_16) AT=145.025n

* CHECK dout0_17 Vdout0_17ck28 = 1.1 time = 145
.meas tran vdout0_17ck28 FIND v(dout0_17) AT=145.025n

* CHECK dout0_18 Vdout0_18ck28 = 1.1 time = 145
.meas tran vdout0_18ck28 FIND v(dout0_18) AT=145.025n

* CHECK dout0_19 Vdout0_19ck28 = 0 time = 145
.meas tran vdout0_19ck28 FIND v(dout0_19) AT=145.025n

* CHECK dout0_20 Vdout0_20ck28 = 0 time = 145
.meas tran vdout0_20ck28 FIND v(dout0_20) AT=145.025n

* CHECK dout0_21 Vdout0_21ck28 = 0 time = 145
.meas tran vdout0_21ck28 FIND v(dout0_21) AT=145.025n

* CHECK dout0_22 Vdout0_22ck28 = 1.1 time = 145
.meas tran vdout0_22ck28 FIND v(dout0_22) AT=145.025n

* CHECK dout0_23 Vdout0_23ck28 = 1.1 time = 145
.meas tran vdout0_23ck28 FIND v(dout0_23) AT=145.025n

* CHECK dout0_24 Vdout0_24ck28 = 0 time = 145
.meas tran vdout0_24ck28 FIND v(dout0_24) AT=145.025n

* CHECK dout0_25 Vdout0_25ck28 = 0 time = 145
.meas tran vdout0_25ck28 FIND v(dout0_25) AT=145.025n

* CHECK dout0_26 Vdout0_26ck28 = 1.1 time = 145
.meas tran vdout0_26ck28 FIND v(dout0_26) AT=145.025n

* CHECK dout0_27 Vdout0_27ck28 = 0 time = 145
.meas tran vdout0_27ck28 FIND v(dout0_27) AT=145.025n

* CHECK dout0_28 Vdout0_28ck28 = 1.1 time = 145
.meas tran vdout0_28ck28 FIND v(dout0_28) AT=145.025n

* CHECK dout0_29 Vdout0_29ck28 = 0 time = 145
.meas tran vdout0_29ck28 FIND v(dout0_29) AT=145.025n

* CHECK dout0_30 Vdout0_30ck28 = 0 time = 145
.meas tran vdout0_30ck28 FIND v(dout0_30) AT=145.025n

* CHECK dout0_31 Vdout0_31ck28 = 1.1 time = 145
.meas tran vdout0_31ck28 FIND v(dout0_31) AT=145.025n

* CHECK dout0_0 Vdout0_0ck30 = 1.1 time = 155
.meas tran vdout0_0ck30 FIND v(dout0_0) AT=155.025n

* CHECK dout0_1 Vdout0_1ck30 = 1.1 time = 155
.meas tran vdout0_1ck30 FIND v(dout0_1) AT=155.025n

* CHECK dout0_2 Vdout0_2ck30 = 0 time = 155
.meas tran vdout0_2ck30 FIND v(dout0_2) AT=155.025n

* CHECK dout0_3 Vdout0_3ck30 = 1.1 time = 155
.meas tran vdout0_3ck30 FIND v(dout0_3) AT=155.025n

* CHECK dout0_4 Vdout0_4ck30 = 0 time = 155
.meas tran vdout0_4ck30 FIND v(dout0_4) AT=155.025n

* CHECK dout0_5 Vdout0_5ck30 = 1.1 time = 155
.meas tran vdout0_5ck30 FIND v(dout0_5) AT=155.025n

* CHECK dout0_6 Vdout0_6ck30 = 0 time = 155
.meas tran vdout0_6ck30 FIND v(dout0_6) AT=155.025n

* CHECK dout0_7 Vdout0_7ck30 = 0 time = 155
.meas tran vdout0_7ck30 FIND v(dout0_7) AT=155.025n

* CHECK dout0_8 Vdout0_8ck30 = 0 time = 155
.meas tran vdout0_8ck30 FIND v(dout0_8) AT=155.025n

* CHECK dout0_9 Vdout0_9ck30 = 0 time = 155
.meas tran vdout0_9ck30 FIND v(dout0_9) AT=155.025n

* CHECK dout0_10 Vdout0_10ck30 = 0 time = 155
.meas tran vdout0_10ck30 FIND v(dout0_10) AT=155.025n

* CHECK dout0_11 Vdout0_11ck30 = 1.1 time = 155
.meas tran vdout0_11ck30 FIND v(dout0_11) AT=155.025n

* CHECK dout0_12 Vdout0_12ck30 = 1.1 time = 155
.meas tran vdout0_12ck30 FIND v(dout0_12) AT=155.025n

* CHECK dout0_13 Vdout0_13ck30 = 0 time = 155
.meas tran vdout0_13ck30 FIND v(dout0_13) AT=155.025n

* CHECK dout0_14 Vdout0_14ck30 = 0 time = 155
.meas tran vdout0_14ck30 FIND v(dout0_14) AT=155.025n

* CHECK dout0_15 Vdout0_15ck30 = 1.1 time = 155
.meas tran vdout0_15ck30 FIND v(dout0_15) AT=155.025n

* CHECK dout0_16 Vdout0_16ck30 = 1.1 time = 155
.meas tran vdout0_16ck30 FIND v(dout0_16) AT=155.025n

* CHECK dout0_17 Vdout0_17ck30 = 0 time = 155
.meas tran vdout0_17ck30 FIND v(dout0_17) AT=155.025n

* CHECK dout0_18 Vdout0_18ck30 = 0 time = 155
.meas tran vdout0_18ck30 FIND v(dout0_18) AT=155.025n

* CHECK dout0_19 Vdout0_19ck30 = 0 time = 155
.meas tran vdout0_19ck30 FIND v(dout0_19) AT=155.025n

* CHECK dout0_20 Vdout0_20ck30 = 1.1 time = 155
.meas tran vdout0_20ck30 FIND v(dout0_20) AT=155.025n

* CHECK dout0_21 Vdout0_21ck30 = 1.1 time = 155
.meas tran vdout0_21ck30 FIND v(dout0_21) AT=155.025n

* CHECK dout0_22 Vdout0_22ck30 = 0 time = 155
.meas tran vdout0_22ck30 FIND v(dout0_22) AT=155.025n

* CHECK dout0_23 Vdout0_23ck30 = 1.1 time = 155
.meas tran vdout0_23ck30 FIND v(dout0_23) AT=155.025n

* CHECK dout0_24 Vdout0_24ck30 = 0 time = 155
.meas tran vdout0_24ck30 FIND v(dout0_24) AT=155.025n

* CHECK dout0_25 Vdout0_25ck30 = 0 time = 155
.meas tran vdout0_25ck30 FIND v(dout0_25) AT=155.025n

* CHECK dout0_26 Vdout0_26ck30 = 0 time = 155
.meas tran vdout0_26ck30 FIND v(dout0_26) AT=155.025n

* CHECK dout0_27 Vdout0_27ck30 = 1.1 time = 155
.meas tran vdout0_27ck30 FIND v(dout0_27) AT=155.025n

* CHECK dout0_28 Vdout0_28ck30 = 1.1 time = 155
.meas tran vdout0_28ck30 FIND v(dout0_28) AT=155.025n

* CHECK dout0_29 Vdout0_29ck30 = 1.1 time = 155
.meas tran vdout0_29ck30 FIND v(dout0_29) AT=155.025n

* CHECK dout0_30 Vdout0_30ck30 = 1.1 time = 155
.meas tran vdout0_30ck30 FIND v(dout0_30) AT=155.025n

* CHECK dout0_31 Vdout0_31ck30 = 1.1 time = 155
.meas tran vdout0_31ck30 FIND v(dout0_31) AT=155.025n

* CHECK dout0_0 Vdout0_0ck33 = 1.1 time = 170
.meas tran vdout0_0ck33 FIND v(dout0_0) AT=170.025n

* CHECK dout0_1 Vdout0_1ck33 = 0 time = 170
.meas tran vdout0_1ck33 FIND v(dout0_1) AT=170.025n

* CHECK dout0_2 Vdout0_2ck33 = 0 time = 170
.meas tran vdout0_2ck33 FIND v(dout0_2) AT=170.025n

* CHECK dout0_3 Vdout0_3ck33 = 1.1 time = 170
.meas tran vdout0_3ck33 FIND v(dout0_3) AT=170.025n

* CHECK dout0_4 Vdout0_4ck33 = 1.1 time = 170
.meas tran vdout0_4ck33 FIND v(dout0_4) AT=170.025n

* CHECK dout0_5 Vdout0_5ck33 = 1.1 time = 170
.meas tran vdout0_5ck33 FIND v(dout0_5) AT=170.025n

* CHECK dout0_6 Vdout0_6ck33 = 1.1 time = 170
.meas tran vdout0_6ck33 FIND v(dout0_6) AT=170.025n

* CHECK dout0_7 Vdout0_7ck33 = 0 time = 170
.meas tran vdout0_7ck33 FIND v(dout0_7) AT=170.025n

* CHECK dout0_8 Vdout0_8ck33 = 0 time = 170
.meas tran vdout0_8ck33 FIND v(dout0_8) AT=170.025n

* CHECK dout0_9 Vdout0_9ck33 = 0 time = 170
.meas tran vdout0_9ck33 FIND v(dout0_9) AT=170.025n

* CHECK dout0_10 Vdout0_10ck33 = 1.1 time = 170
.meas tran vdout0_10ck33 FIND v(dout0_10) AT=170.025n

* CHECK dout0_11 Vdout0_11ck33 = 1.1 time = 170
.meas tran vdout0_11ck33 FIND v(dout0_11) AT=170.025n

* CHECK dout0_12 Vdout0_12ck33 = 1.1 time = 170
.meas tran vdout0_12ck33 FIND v(dout0_12) AT=170.025n

* CHECK dout0_13 Vdout0_13ck33 = 1.1 time = 170
.meas tran vdout0_13ck33 FIND v(dout0_13) AT=170.025n

* CHECK dout0_14 Vdout0_14ck33 = 1.1 time = 170
.meas tran vdout0_14ck33 FIND v(dout0_14) AT=170.025n

* CHECK dout0_15 Vdout0_15ck33 = 0 time = 170
.meas tran vdout0_15ck33 FIND v(dout0_15) AT=170.025n

* CHECK dout0_16 Vdout0_16ck33 = 0 time = 170
.meas tran vdout0_16ck33 FIND v(dout0_16) AT=170.025n

* CHECK dout0_17 Vdout0_17ck33 = 1.1 time = 170
.meas tran vdout0_17ck33 FIND v(dout0_17) AT=170.025n

* CHECK dout0_18 Vdout0_18ck33 = 1.1 time = 170
.meas tran vdout0_18ck33 FIND v(dout0_18) AT=170.025n

* CHECK dout0_19 Vdout0_19ck33 = 0 time = 170
.meas tran vdout0_19ck33 FIND v(dout0_19) AT=170.025n

* CHECK dout0_20 Vdout0_20ck33 = 0 time = 170
.meas tran vdout0_20ck33 FIND v(dout0_20) AT=170.025n

* CHECK dout0_21 Vdout0_21ck33 = 0 time = 170
.meas tran vdout0_21ck33 FIND v(dout0_21) AT=170.025n

* CHECK dout0_22 Vdout0_22ck33 = 1.1 time = 170
.meas tran vdout0_22ck33 FIND v(dout0_22) AT=170.025n

* CHECK dout0_23 Vdout0_23ck33 = 1.1 time = 170
.meas tran vdout0_23ck33 FIND v(dout0_23) AT=170.025n

* CHECK dout0_24 Vdout0_24ck33 = 0 time = 170
.meas tran vdout0_24ck33 FIND v(dout0_24) AT=170.025n

* CHECK dout0_25 Vdout0_25ck33 = 0 time = 170
.meas tran vdout0_25ck33 FIND v(dout0_25) AT=170.025n

* CHECK dout0_26 Vdout0_26ck33 = 1.1 time = 170
.meas tran vdout0_26ck33 FIND v(dout0_26) AT=170.025n

* CHECK dout0_27 Vdout0_27ck33 = 0 time = 170
.meas tran vdout0_27ck33 FIND v(dout0_27) AT=170.025n

* CHECK dout0_28 Vdout0_28ck33 = 1.1 time = 170
.meas tran vdout0_28ck33 FIND v(dout0_28) AT=170.025n

* CHECK dout0_29 Vdout0_29ck33 = 0 time = 170
.meas tran vdout0_29ck33 FIND v(dout0_29) AT=170.025n

* CHECK dout0_30 Vdout0_30ck33 = 0 time = 170
.meas tran vdout0_30ck33 FIND v(dout0_30) AT=170.025n

* CHECK dout0_31 Vdout0_31ck33 = 1.1 time = 170
.meas tran vdout0_31ck33 FIND v(dout0_31) AT=170.025n

* CHECK dout0_0 Vdout0_0ck34 = 1.1 time = 175
.meas tran vdout0_0ck34 FIND v(dout0_0) AT=175.025n

* CHECK dout0_1 Vdout0_1ck34 = 1.1 time = 175
.meas tran vdout0_1ck34 FIND v(dout0_1) AT=175.025n

* CHECK dout0_2 Vdout0_2ck34 = 0 time = 175
.meas tran vdout0_2ck34 FIND v(dout0_2) AT=175.025n

* CHECK dout0_3 Vdout0_3ck34 = 1.1 time = 175
.meas tran vdout0_3ck34 FIND v(dout0_3) AT=175.025n

* CHECK dout0_4 Vdout0_4ck34 = 0 time = 175
.meas tran vdout0_4ck34 FIND v(dout0_4) AT=175.025n

* CHECK dout0_5 Vdout0_5ck34 = 1.1 time = 175
.meas tran vdout0_5ck34 FIND v(dout0_5) AT=175.025n

* CHECK dout0_6 Vdout0_6ck34 = 0 time = 175
.meas tran vdout0_6ck34 FIND v(dout0_6) AT=175.025n

* CHECK dout0_7 Vdout0_7ck34 = 0 time = 175
.meas tran vdout0_7ck34 FIND v(dout0_7) AT=175.025n

* CHECK dout0_8 Vdout0_8ck34 = 0 time = 175
.meas tran vdout0_8ck34 FIND v(dout0_8) AT=175.025n

* CHECK dout0_9 Vdout0_9ck34 = 0 time = 175
.meas tran vdout0_9ck34 FIND v(dout0_9) AT=175.025n

* CHECK dout0_10 Vdout0_10ck34 = 0 time = 175
.meas tran vdout0_10ck34 FIND v(dout0_10) AT=175.025n

* CHECK dout0_11 Vdout0_11ck34 = 1.1 time = 175
.meas tran vdout0_11ck34 FIND v(dout0_11) AT=175.025n

* CHECK dout0_12 Vdout0_12ck34 = 1.1 time = 175
.meas tran vdout0_12ck34 FIND v(dout0_12) AT=175.025n

* CHECK dout0_13 Vdout0_13ck34 = 0 time = 175
.meas tran vdout0_13ck34 FIND v(dout0_13) AT=175.025n

* CHECK dout0_14 Vdout0_14ck34 = 0 time = 175
.meas tran vdout0_14ck34 FIND v(dout0_14) AT=175.025n

* CHECK dout0_15 Vdout0_15ck34 = 1.1 time = 175
.meas tran vdout0_15ck34 FIND v(dout0_15) AT=175.025n

* CHECK dout0_16 Vdout0_16ck34 = 1.1 time = 175
.meas tran vdout0_16ck34 FIND v(dout0_16) AT=175.025n

* CHECK dout0_17 Vdout0_17ck34 = 0 time = 175
.meas tran vdout0_17ck34 FIND v(dout0_17) AT=175.025n

* CHECK dout0_18 Vdout0_18ck34 = 0 time = 175
.meas tran vdout0_18ck34 FIND v(dout0_18) AT=175.025n

* CHECK dout0_19 Vdout0_19ck34 = 0 time = 175
.meas tran vdout0_19ck34 FIND v(dout0_19) AT=175.025n

* CHECK dout0_20 Vdout0_20ck34 = 1.1 time = 175
.meas tran vdout0_20ck34 FIND v(dout0_20) AT=175.025n

* CHECK dout0_21 Vdout0_21ck34 = 1.1 time = 175
.meas tran vdout0_21ck34 FIND v(dout0_21) AT=175.025n

* CHECK dout0_22 Vdout0_22ck34 = 0 time = 175
.meas tran vdout0_22ck34 FIND v(dout0_22) AT=175.025n

* CHECK dout0_23 Vdout0_23ck34 = 1.1 time = 175
.meas tran vdout0_23ck34 FIND v(dout0_23) AT=175.025n

* CHECK dout0_24 Vdout0_24ck34 = 0 time = 175
.meas tran vdout0_24ck34 FIND v(dout0_24) AT=175.025n

* CHECK dout0_25 Vdout0_25ck34 = 0 time = 175
.meas tran vdout0_25ck34 FIND v(dout0_25) AT=175.025n

* CHECK dout0_26 Vdout0_26ck34 = 0 time = 175
.meas tran vdout0_26ck34 FIND v(dout0_26) AT=175.025n

* CHECK dout0_27 Vdout0_27ck34 = 1.1 time = 175
.meas tran vdout0_27ck34 FIND v(dout0_27) AT=175.025n

* CHECK dout0_28 Vdout0_28ck34 = 1.1 time = 175
.meas tran vdout0_28ck34 FIND v(dout0_28) AT=175.025n

* CHECK dout0_29 Vdout0_29ck34 = 1.1 time = 175
.meas tran vdout0_29ck34 FIND v(dout0_29) AT=175.025n

* CHECK dout0_30 Vdout0_30ck34 = 1.1 time = 175
.meas tran vdout0_30ck34 FIND v(dout0_30) AT=175.025n

* CHECK dout0_31 Vdout0_31ck34 = 1.1 time = 175
.meas tran vdout0_31ck34 FIND v(dout0_31) AT=175.025n

* CHECK dout0_0 Vdout0_0ck35 = 0 time = 180
.meas tran vdout0_0ck35 FIND v(dout0_0) AT=180.025n

* CHECK dout0_1 Vdout0_1ck35 = 1.1 time = 180
.meas tran vdout0_1ck35 FIND v(dout0_1) AT=180.025n

* CHECK dout0_2 Vdout0_2ck35 = 0 time = 180
.meas tran vdout0_2ck35 FIND v(dout0_2) AT=180.025n

* CHECK dout0_3 Vdout0_3ck35 = 0 time = 180
.meas tran vdout0_3ck35 FIND v(dout0_3) AT=180.025n

* CHECK dout0_4 Vdout0_4ck35 = 1.1 time = 180
.meas tran vdout0_4ck35 FIND v(dout0_4) AT=180.025n

* CHECK dout0_5 Vdout0_5ck35 = 0 time = 180
.meas tran vdout0_5ck35 FIND v(dout0_5) AT=180.025n

* CHECK dout0_6 Vdout0_6ck35 = 0 time = 180
.meas tran vdout0_6ck35 FIND v(dout0_6) AT=180.025n

* CHECK dout0_7 Vdout0_7ck35 = 0 time = 180
.meas tran vdout0_7ck35 FIND v(dout0_7) AT=180.025n

* CHECK dout0_8 Vdout0_8ck35 = 1.1 time = 180
.meas tran vdout0_8ck35 FIND v(dout0_8) AT=180.025n

* CHECK dout0_9 Vdout0_9ck35 = 1.1 time = 180
.meas tran vdout0_9ck35 FIND v(dout0_9) AT=180.025n

* CHECK dout0_10 Vdout0_10ck35 = 1.1 time = 180
.meas tran vdout0_10ck35 FIND v(dout0_10) AT=180.025n

* CHECK dout0_11 Vdout0_11ck35 = 1.1 time = 180
.meas tran vdout0_11ck35 FIND v(dout0_11) AT=180.025n

* CHECK dout0_12 Vdout0_12ck35 = 1.1 time = 180
.meas tran vdout0_12ck35 FIND v(dout0_12) AT=180.025n

* CHECK dout0_13 Vdout0_13ck35 = 0 time = 180
.meas tran vdout0_13ck35 FIND v(dout0_13) AT=180.025n

* CHECK dout0_14 Vdout0_14ck35 = 1.1 time = 180
.meas tran vdout0_14ck35 FIND v(dout0_14) AT=180.025n

* CHECK dout0_15 Vdout0_15ck35 = 1.1 time = 180
.meas tran vdout0_15ck35 FIND v(dout0_15) AT=180.025n

* CHECK dout0_16 Vdout0_16ck35 = 0 time = 180
.meas tran vdout0_16ck35 FIND v(dout0_16) AT=180.025n

* CHECK dout0_17 Vdout0_17ck35 = 1.1 time = 180
.meas tran vdout0_17ck35 FIND v(dout0_17) AT=180.025n

* CHECK dout0_18 Vdout0_18ck35 = 0 time = 180
.meas tran vdout0_18ck35 FIND v(dout0_18) AT=180.025n

* CHECK dout0_19 Vdout0_19ck35 = 1.1 time = 180
.meas tran vdout0_19ck35 FIND v(dout0_19) AT=180.025n

* CHECK dout0_20 Vdout0_20ck35 = 0 time = 180
.meas tran vdout0_20ck35 FIND v(dout0_20) AT=180.025n

* CHECK dout0_21 Vdout0_21ck35 = 1.1 time = 180
.meas tran vdout0_21ck35 FIND v(dout0_21) AT=180.025n

* CHECK dout0_22 Vdout0_22ck35 = 1.1 time = 180
.meas tran vdout0_22ck35 FIND v(dout0_22) AT=180.025n

* CHECK dout0_23 Vdout0_23ck35 = 0 time = 180
.meas tran vdout0_23ck35 FIND v(dout0_23) AT=180.025n

* CHECK dout0_24 Vdout0_24ck35 = 1.1 time = 180
.meas tran vdout0_24ck35 FIND v(dout0_24) AT=180.025n

* CHECK dout0_25 Vdout0_25ck35 = 1.1 time = 180
.meas tran vdout0_25ck35 FIND v(dout0_25) AT=180.025n

* CHECK dout0_26 Vdout0_26ck35 = 0 time = 180
.meas tran vdout0_26ck35 FIND v(dout0_26) AT=180.025n

* CHECK dout0_27 Vdout0_27ck35 = 0 time = 180
.meas tran vdout0_27ck35 FIND v(dout0_27) AT=180.025n

* CHECK dout0_28 Vdout0_28ck35 = 1.1 time = 180
.meas tran vdout0_28ck35 FIND v(dout0_28) AT=180.025n

* CHECK dout0_29 Vdout0_29ck35 = 0 time = 180
.meas tran vdout0_29ck35 FIND v(dout0_29) AT=180.025n

* CHECK dout0_30 Vdout0_30ck35 = 0 time = 180
.meas tran vdout0_30ck35 FIND v(dout0_30) AT=180.025n

* CHECK dout0_31 Vdout0_31ck35 = 1.1 time = 180
.meas tran vdout0_31ck35 FIND v(dout0_31) AT=180.025n

* CHECK dout0_0 Vdout0_0ck36 = 1.1 time = 185
.meas tran vdout0_0ck36 FIND v(dout0_0) AT=185.025n

* CHECK dout0_1 Vdout0_1ck36 = 0 time = 185
.meas tran vdout0_1ck36 FIND v(dout0_1) AT=185.025n

* CHECK dout0_2 Vdout0_2ck36 = 0 time = 185
.meas tran vdout0_2ck36 FIND v(dout0_2) AT=185.025n

* CHECK dout0_3 Vdout0_3ck36 = 1.1 time = 185
.meas tran vdout0_3ck36 FIND v(dout0_3) AT=185.025n

* CHECK dout0_4 Vdout0_4ck36 = 1.1 time = 185
.meas tran vdout0_4ck36 FIND v(dout0_4) AT=185.025n

* CHECK dout0_5 Vdout0_5ck36 = 1.1 time = 185
.meas tran vdout0_5ck36 FIND v(dout0_5) AT=185.025n

* CHECK dout0_6 Vdout0_6ck36 = 1.1 time = 185
.meas tran vdout0_6ck36 FIND v(dout0_6) AT=185.025n

* CHECK dout0_7 Vdout0_7ck36 = 0 time = 185
.meas tran vdout0_7ck36 FIND v(dout0_7) AT=185.025n

* CHECK dout0_8 Vdout0_8ck36 = 0 time = 185
.meas tran vdout0_8ck36 FIND v(dout0_8) AT=185.025n

* CHECK dout0_9 Vdout0_9ck36 = 0 time = 185
.meas tran vdout0_9ck36 FIND v(dout0_9) AT=185.025n

* CHECK dout0_10 Vdout0_10ck36 = 1.1 time = 185
.meas tran vdout0_10ck36 FIND v(dout0_10) AT=185.025n

* CHECK dout0_11 Vdout0_11ck36 = 1.1 time = 185
.meas tran vdout0_11ck36 FIND v(dout0_11) AT=185.025n

* CHECK dout0_12 Vdout0_12ck36 = 1.1 time = 185
.meas tran vdout0_12ck36 FIND v(dout0_12) AT=185.025n

* CHECK dout0_13 Vdout0_13ck36 = 1.1 time = 185
.meas tran vdout0_13ck36 FIND v(dout0_13) AT=185.025n

* CHECK dout0_14 Vdout0_14ck36 = 1.1 time = 185
.meas tran vdout0_14ck36 FIND v(dout0_14) AT=185.025n

* CHECK dout0_15 Vdout0_15ck36 = 0 time = 185
.meas tran vdout0_15ck36 FIND v(dout0_15) AT=185.025n

* CHECK dout0_16 Vdout0_16ck36 = 0 time = 185
.meas tran vdout0_16ck36 FIND v(dout0_16) AT=185.025n

* CHECK dout0_17 Vdout0_17ck36 = 1.1 time = 185
.meas tran vdout0_17ck36 FIND v(dout0_17) AT=185.025n

* CHECK dout0_18 Vdout0_18ck36 = 1.1 time = 185
.meas tran vdout0_18ck36 FIND v(dout0_18) AT=185.025n

* CHECK dout0_19 Vdout0_19ck36 = 0 time = 185
.meas tran vdout0_19ck36 FIND v(dout0_19) AT=185.025n

* CHECK dout0_20 Vdout0_20ck36 = 0 time = 185
.meas tran vdout0_20ck36 FIND v(dout0_20) AT=185.025n

* CHECK dout0_21 Vdout0_21ck36 = 0 time = 185
.meas tran vdout0_21ck36 FIND v(dout0_21) AT=185.025n

* CHECK dout0_22 Vdout0_22ck36 = 1.1 time = 185
.meas tran vdout0_22ck36 FIND v(dout0_22) AT=185.025n

* CHECK dout0_23 Vdout0_23ck36 = 1.1 time = 185
.meas tran vdout0_23ck36 FIND v(dout0_23) AT=185.025n

* CHECK dout0_24 Vdout0_24ck36 = 0 time = 185
.meas tran vdout0_24ck36 FIND v(dout0_24) AT=185.025n

* CHECK dout0_25 Vdout0_25ck36 = 0 time = 185
.meas tran vdout0_25ck36 FIND v(dout0_25) AT=185.025n

* CHECK dout0_26 Vdout0_26ck36 = 1.1 time = 185
.meas tran vdout0_26ck36 FIND v(dout0_26) AT=185.025n

* CHECK dout0_27 Vdout0_27ck36 = 0 time = 185
.meas tran vdout0_27ck36 FIND v(dout0_27) AT=185.025n

* CHECK dout0_28 Vdout0_28ck36 = 1.1 time = 185
.meas tran vdout0_28ck36 FIND v(dout0_28) AT=185.025n

* CHECK dout0_29 Vdout0_29ck36 = 0 time = 185
.meas tran vdout0_29ck36 FIND v(dout0_29) AT=185.025n

* CHECK dout0_30 Vdout0_30ck36 = 0 time = 185
.meas tran vdout0_30ck36 FIND v(dout0_30) AT=185.025n

* CHECK dout0_31 Vdout0_31ck36 = 1.1 time = 185
.meas tran vdout0_31ck36 FIND v(dout0_31) AT=185.025n

* CHECK dout0_0 Vdout0_0ck38 = 0 time = 195
.meas tran vdout0_0ck38 FIND v(dout0_0) AT=195.025n

* CHECK dout0_1 Vdout0_1ck38 = 1.1 time = 195
.meas tran vdout0_1ck38 FIND v(dout0_1) AT=195.025n

* CHECK dout0_2 Vdout0_2ck38 = 0 time = 195
.meas tran vdout0_2ck38 FIND v(dout0_2) AT=195.025n

* CHECK dout0_3 Vdout0_3ck38 = 0 time = 195
.meas tran vdout0_3ck38 FIND v(dout0_3) AT=195.025n

* CHECK dout0_4 Vdout0_4ck38 = 1.1 time = 195
.meas tran vdout0_4ck38 FIND v(dout0_4) AT=195.025n

* CHECK dout0_5 Vdout0_5ck38 = 0 time = 195
.meas tran vdout0_5ck38 FIND v(dout0_5) AT=195.025n

* CHECK dout0_6 Vdout0_6ck38 = 0 time = 195
.meas tran vdout0_6ck38 FIND v(dout0_6) AT=195.025n

* CHECK dout0_7 Vdout0_7ck38 = 0 time = 195
.meas tran vdout0_7ck38 FIND v(dout0_7) AT=195.025n

* CHECK dout0_8 Vdout0_8ck38 = 1.1 time = 195
.meas tran vdout0_8ck38 FIND v(dout0_8) AT=195.025n

* CHECK dout0_9 Vdout0_9ck38 = 1.1 time = 195
.meas tran vdout0_9ck38 FIND v(dout0_9) AT=195.025n

* CHECK dout0_10 Vdout0_10ck38 = 1.1 time = 195
.meas tran vdout0_10ck38 FIND v(dout0_10) AT=195.025n

* CHECK dout0_11 Vdout0_11ck38 = 1.1 time = 195
.meas tran vdout0_11ck38 FIND v(dout0_11) AT=195.025n

* CHECK dout0_12 Vdout0_12ck38 = 1.1 time = 195
.meas tran vdout0_12ck38 FIND v(dout0_12) AT=195.025n

* CHECK dout0_13 Vdout0_13ck38 = 0 time = 195
.meas tran vdout0_13ck38 FIND v(dout0_13) AT=195.025n

* CHECK dout0_14 Vdout0_14ck38 = 1.1 time = 195
.meas tran vdout0_14ck38 FIND v(dout0_14) AT=195.025n

* CHECK dout0_15 Vdout0_15ck38 = 1.1 time = 195
.meas tran vdout0_15ck38 FIND v(dout0_15) AT=195.025n

* CHECK dout0_16 Vdout0_16ck38 = 0 time = 195
.meas tran vdout0_16ck38 FIND v(dout0_16) AT=195.025n

* CHECK dout0_17 Vdout0_17ck38 = 1.1 time = 195
.meas tran vdout0_17ck38 FIND v(dout0_17) AT=195.025n

* CHECK dout0_18 Vdout0_18ck38 = 0 time = 195
.meas tran vdout0_18ck38 FIND v(dout0_18) AT=195.025n

* CHECK dout0_19 Vdout0_19ck38 = 1.1 time = 195
.meas tran vdout0_19ck38 FIND v(dout0_19) AT=195.025n

* CHECK dout0_20 Vdout0_20ck38 = 0 time = 195
.meas tran vdout0_20ck38 FIND v(dout0_20) AT=195.025n

* CHECK dout0_21 Vdout0_21ck38 = 1.1 time = 195
.meas tran vdout0_21ck38 FIND v(dout0_21) AT=195.025n

* CHECK dout0_22 Vdout0_22ck38 = 1.1 time = 195
.meas tran vdout0_22ck38 FIND v(dout0_22) AT=195.025n

* CHECK dout0_23 Vdout0_23ck38 = 0 time = 195
.meas tran vdout0_23ck38 FIND v(dout0_23) AT=195.025n

* CHECK dout0_24 Vdout0_24ck38 = 1.1 time = 195
.meas tran vdout0_24ck38 FIND v(dout0_24) AT=195.025n

* CHECK dout0_25 Vdout0_25ck38 = 1.1 time = 195
.meas tran vdout0_25ck38 FIND v(dout0_25) AT=195.025n

* CHECK dout0_26 Vdout0_26ck38 = 0 time = 195
.meas tran vdout0_26ck38 FIND v(dout0_26) AT=195.025n

* CHECK dout0_27 Vdout0_27ck38 = 0 time = 195
.meas tran vdout0_27ck38 FIND v(dout0_27) AT=195.025n

* CHECK dout0_28 Vdout0_28ck38 = 1.1 time = 195
.meas tran vdout0_28ck38 FIND v(dout0_28) AT=195.025n

* CHECK dout0_29 Vdout0_29ck38 = 0 time = 195
.meas tran vdout0_29ck38 FIND v(dout0_29) AT=195.025n

* CHECK dout0_30 Vdout0_30ck38 = 0 time = 195
.meas tran vdout0_30ck38 FIND v(dout0_30) AT=195.025n

* CHECK dout0_31 Vdout0_31ck38 = 1.1 time = 195
.meas tran vdout0_31ck38 FIND v(dout0_31) AT=195.025n

* CHECK dout0_0 Vdout0_0ck40 = 0 time = 205
.meas tran vdout0_0ck40 FIND v(dout0_0) AT=205.025n

* CHECK dout0_1 Vdout0_1ck40 = 0 time = 205
.meas tran vdout0_1ck40 FIND v(dout0_1) AT=205.025n

* CHECK dout0_2 Vdout0_2ck40 = 0 time = 205
.meas tran vdout0_2ck40 FIND v(dout0_2) AT=205.025n

* CHECK dout0_3 Vdout0_3ck40 = 0 time = 205
.meas tran vdout0_3ck40 FIND v(dout0_3) AT=205.025n

* CHECK dout0_4 Vdout0_4ck40 = 0 time = 205
.meas tran vdout0_4ck40 FIND v(dout0_4) AT=205.025n

* CHECK dout0_5 Vdout0_5ck40 = 0 time = 205
.meas tran vdout0_5ck40 FIND v(dout0_5) AT=205.025n

* CHECK dout0_6 Vdout0_6ck40 = 1.1 time = 205
.meas tran vdout0_6ck40 FIND v(dout0_6) AT=205.025n

* CHECK dout0_7 Vdout0_7ck40 = 0 time = 205
.meas tran vdout0_7ck40 FIND v(dout0_7) AT=205.025n

* CHECK dout0_8 Vdout0_8ck40 = 0 time = 205
.meas tran vdout0_8ck40 FIND v(dout0_8) AT=205.025n

* CHECK dout0_9 Vdout0_9ck40 = 0 time = 205
.meas tran vdout0_9ck40 FIND v(dout0_9) AT=205.025n

* CHECK dout0_10 Vdout0_10ck40 = 0 time = 205
.meas tran vdout0_10ck40 FIND v(dout0_10) AT=205.025n

* CHECK dout0_11 Vdout0_11ck40 = 1.1 time = 205
.meas tran vdout0_11ck40 FIND v(dout0_11) AT=205.025n

* CHECK dout0_12 Vdout0_12ck40 = 0 time = 205
.meas tran vdout0_12ck40 FIND v(dout0_12) AT=205.025n

* CHECK dout0_13 Vdout0_13ck40 = 1.1 time = 205
.meas tran vdout0_13ck40 FIND v(dout0_13) AT=205.025n

* CHECK dout0_14 Vdout0_14ck40 = 0 time = 205
.meas tran vdout0_14ck40 FIND v(dout0_14) AT=205.025n

* CHECK dout0_15 Vdout0_15ck40 = 1.1 time = 205
.meas tran vdout0_15ck40 FIND v(dout0_15) AT=205.025n

* CHECK dout0_16 Vdout0_16ck40 = 1.1 time = 205
.meas tran vdout0_16ck40 FIND v(dout0_16) AT=205.025n

* CHECK dout0_17 Vdout0_17ck40 = 1.1 time = 205
.meas tran vdout0_17ck40 FIND v(dout0_17) AT=205.025n

* CHECK dout0_18 Vdout0_18ck40 = 0 time = 205
.meas tran vdout0_18ck40 FIND v(dout0_18) AT=205.025n

* CHECK dout0_19 Vdout0_19ck40 = 0 time = 205
.meas tran vdout0_19ck40 FIND v(dout0_19) AT=205.025n

* CHECK dout0_20 Vdout0_20ck40 = 1.1 time = 205
.meas tran vdout0_20ck40 FIND v(dout0_20) AT=205.025n

* CHECK dout0_21 Vdout0_21ck40 = 0 time = 205
.meas tran vdout0_21ck40 FIND v(dout0_21) AT=205.025n

* CHECK dout0_22 Vdout0_22ck40 = 0 time = 205
.meas tran vdout0_22ck40 FIND v(dout0_22) AT=205.025n

* CHECK dout0_23 Vdout0_23ck40 = 0 time = 205
.meas tran vdout0_23ck40 FIND v(dout0_23) AT=205.025n

* CHECK dout0_24 Vdout0_24ck40 = 0 time = 205
.meas tran vdout0_24ck40 FIND v(dout0_24) AT=205.025n

* CHECK dout0_25 Vdout0_25ck40 = 1.1 time = 205
.meas tran vdout0_25ck40 FIND v(dout0_25) AT=205.025n

* CHECK dout0_26 Vdout0_26ck40 = 1.1 time = 205
.meas tran vdout0_26ck40 FIND v(dout0_26) AT=205.025n

* CHECK dout0_27 Vdout0_27ck40 = 1.1 time = 205
.meas tran vdout0_27ck40 FIND v(dout0_27) AT=205.025n

* CHECK dout0_28 Vdout0_28ck40 = 1.1 time = 205
.meas tran vdout0_28ck40 FIND v(dout0_28) AT=205.025n

* CHECK dout0_29 Vdout0_29ck40 = 0 time = 205
.meas tran vdout0_29ck40 FIND v(dout0_29) AT=205.025n

* CHECK dout0_30 Vdout0_30ck40 = 0 time = 205
.meas tran vdout0_30ck40 FIND v(dout0_30) AT=205.025n

* CHECK dout0_31 Vdout0_31ck40 = 1.1 time = 205
.meas tran vdout0_31ck40 FIND v(dout0_31) AT=205.025n

* CHECK dout0_0 Vdout0_0ck41 = 0 time = 210
.meas tran vdout0_0ck41 FIND v(dout0_0) AT=210.025n

* CHECK dout0_1 Vdout0_1ck41 = 0 time = 210
.meas tran vdout0_1ck41 FIND v(dout0_1) AT=210.025n

* CHECK dout0_2 Vdout0_2ck41 = 0 time = 210
.meas tran vdout0_2ck41 FIND v(dout0_2) AT=210.025n

* CHECK dout0_3 Vdout0_3ck41 = 0 time = 210
.meas tran vdout0_3ck41 FIND v(dout0_3) AT=210.025n

* CHECK dout0_4 Vdout0_4ck41 = 0 time = 210
.meas tran vdout0_4ck41 FIND v(dout0_4) AT=210.025n

* CHECK dout0_5 Vdout0_5ck41 = 0 time = 210
.meas tran vdout0_5ck41 FIND v(dout0_5) AT=210.025n

* CHECK dout0_6 Vdout0_6ck41 = 1.1 time = 210
.meas tran vdout0_6ck41 FIND v(dout0_6) AT=210.025n

* CHECK dout0_7 Vdout0_7ck41 = 0 time = 210
.meas tran vdout0_7ck41 FIND v(dout0_7) AT=210.025n

* CHECK dout0_8 Vdout0_8ck41 = 0 time = 210
.meas tran vdout0_8ck41 FIND v(dout0_8) AT=210.025n

* CHECK dout0_9 Vdout0_9ck41 = 0 time = 210
.meas tran vdout0_9ck41 FIND v(dout0_9) AT=210.025n

* CHECK dout0_10 Vdout0_10ck41 = 0 time = 210
.meas tran vdout0_10ck41 FIND v(dout0_10) AT=210.025n

* CHECK dout0_11 Vdout0_11ck41 = 1.1 time = 210
.meas tran vdout0_11ck41 FIND v(dout0_11) AT=210.025n

* CHECK dout0_12 Vdout0_12ck41 = 0 time = 210
.meas tran vdout0_12ck41 FIND v(dout0_12) AT=210.025n

* CHECK dout0_13 Vdout0_13ck41 = 1.1 time = 210
.meas tran vdout0_13ck41 FIND v(dout0_13) AT=210.025n

* CHECK dout0_14 Vdout0_14ck41 = 0 time = 210
.meas tran vdout0_14ck41 FIND v(dout0_14) AT=210.025n

* CHECK dout0_15 Vdout0_15ck41 = 1.1 time = 210
.meas tran vdout0_15ck41 FIND v(dout0_15) AT=210.025n

* CHECK dout0_16 Vdout0_16ck41 = 1.1 time = 210
.meas tran vdout0_16ck41 FIND v(dout0_16) AT=210.025n

* CHECK dout0_17 Vdout0_17ck41 = 1.1 time = 210
.meas tran vdout0_17ck41 FIND v(dout0_17) AT=210.025n

* CHECK dout0_18 Vdout0_18ck41 = 0 time = 210
.meas tran vdout0_18ck41 FIND v(dout0_18) AT=210.025n

* CHECK dout0_19 Vdout0_19ck41 = 0 time = 210
.meas tran vdout0_19ck41 FIND v(dout0_19) AT=210.025n

* CHECK dout0_20 Vdout0_20ck41 = 1.1 time = 210
.meas tran vdout0_20ck41 FIND v(dout0_20) AT=210.025n

* CHECK dout0_21 Vdout0_21ck41 = 0 time = 210
.meas tran vdout0_21ck41 FIND v(dout0_21) AT=210.025n

* CHECK dout0_22 Vdout0_22ck41 = 0 time = 210
.meas tran vdout0_22ck41 FIND v(dout0_22) AT=210.025n

* CHECK dout0_23 Vdout0_23ck41 = 0 time = 210
.meas tran vdout0_23ck41 FIND v(dout0_23) AT=210.025n

* CHECK dout0_24 Vdout0_24ck41 = 0 time = 210
.meas tran vdout0_24ck41 FIND v(dout0_24) AT=210.025n

* CHECK dout0_25 Vdout0_25ck41 = 1.1 time = 210
.meas tran vdout0_25ck41 FIND v(dout0_25) AT=210.025n

* CHECK dout0_26 Vdout0_26ck41 = 1.1 time = 210
.meas tran vdout0_26ck41 FIND v(dout0_26) AT=210.025n

* CHECK dout0_27 Vdout0_27ck41 = 1.1 time = 210
.meas tran vdout0_27ck41 FIND v(dout0_27) AT=210.025n

* CHECK dout0_28 Vdout0_28ck41 = 1.1 time = 210
.meas tran vdout0_28ck41 FIND v(dout0_28) AT=210.025n

* CHECK dout0_29 Vdout0_29ck41 = 0 time = 210
.meas tran vdout0_29ck41 FIND v(dout0_29) AT=210.025n

* CHECK dout0_30 Vdout0_30ck41 = 0 time = 210
.meas tran vdout0_30ck41 FIND v(dout0_30) AT=210.025n

* CHECK dout0_31 Vdout0_31ck41 = 1.1 time = 210
.meas tran vdout0_31ck41 FIND v(dout0_31) AT=210.025n

* CHECK dout0_0 Vdout0_0ck50 = 1.1 time = 255
.meas tran vdout0_0ck50 FIND v(dout0_0) AT=255.025n

* CHECK dout0_1 Vdout0_1ck50 = 0 time = 255
.meas tran vdout0_1ck50 FIND v(dout0_1) AT=255.025n

* CHECK dout0_2 Vdout0_2ck50 = 1.1 time = 255
.meas tran vdout0_2ck50 FIND v(dout0_2) AT=255.025n

* CHECK dout0_3 Vdout0_3ck50 = 0 time = 255
.meas tran vdout0_3ck50 FIND v(dout0_3) AT=255.025n

* CHECK dout0_4 Vdout0_4ck50 = 0 time = 255
.meas tran vdout0_4ck50 FIND v(dout0_4) AT=255.025n

* CHECK dout0_5 Vdout0_5ck50 = 1.1 time = 255
.meas tran vdout0_5ck50 FIND v(dout0_5) AT=255.025n

* CHECK dout0_6 Vdout0_6ck50 = 1.1 time = 255
.meas tran vdout0_6ck50 FIND v(dout0_6) AT=255.025n

* CHECK dout0_7 Vdout0_7ck50 = 0 time = 255
.meas tran vdout0_7ck50 FIND v(dout0_7) AT=255.025n

* CHECK dout0_8 Vdout0_8ck50 = 1.1 time = 255
.meas tran vdout0_8ck50 FIND v(dout0_8) AT=255.025n

* CHECK dout0_9 Vdout0_9ck50 = 0 time = 255
.meas tran vdout0_9ck50 FIND v(dout0_9) AT=255.025n

* CHECK dout0_10 Vdout0_10ck50 = 0 time = 255
.meas tran vdout0_10ck50 FIND v(dout0_10) AT=255.025n

* CHECK dout0_11 Vdout0_11ck50 = 1.1 time = 255
.meas tran vdout0_11ck50 FIND v(dout0_11) AT=255.025n

* CHECK dout0_12 Vdout0_12ck50 = 1.1 time = 255
.meas tran vdout0_12ck50 FIND v(dout0_12) AT=255.025n

* CHECK dout0_13 Vdout0_13ck50 = 0 time = 255
.meas tran vdout0_13ck50 FIND v(dout0_13) AT=255.025n

* CHECK dout0_14 Vdout0_14ck50 = 0 time = 255
.meas tran vdout0_14ck50 FIND v(dout0_14) AT=255.025n

* CHECK dout0_15 Vdout0_15ck50 = 1.1 time = 255
.meas tran vdout0_15ck50 FIND v(dout0_15) AT=255.025n

* CHECK dout0_16 Vdout0_16ck50 = 1.1 time = 255
.meas tran vdout0_16ck50 FIND v(dout0_16) AT=255.025n

* CHECK dout0_17 Vdout0_17ck50 = 1.1 time = 255
.meas tran vdout0_17ck50 FIND v(dout0_17) AT=255.025n

* CHECK dout0_18 Vdout0_18ck50 = 0 time = 255
.meas tran vdout0_18ck50 FIND v(dout0_18) AT=255.025n

* CHECK dout0_19 Vdout0_19ck50 = 0 time = 255
.meas tran vdout0_19ck50 FIND v(dout0_19) AT=255.025n

* CHECK dout0_20 Vdout0_20ck50 = 1.1 time = 255
.meas tran vdout0_20ck50 FIND v(dout0_20) AT=255.025n

* CHECK dout0_21 Vdout0_21ck50 = 1.1 time = 255
.meas tran vdout0_21ck50 FIND v(dout0_21) AT=255.025n

* CHECK dout0_22 Vdout0_22ck50 = 0 time = 255
.meas tran vdout0_22ck50 FIND v(dout0_22) AT=255.025n

* CHECK dout0_23 Vdout0_23ck50 = 1.1 time = 255
.meas tran vdout0_23ck50 FIND v(dout0_23) AT=255.025n

* CHECK dout0_24 Vdout0_24ck50 = 0 time = 255
.meas tran vdout0_24ck50 FIND v(dout0_24) AT=255.025n

* CHECK dout0_25 Vdout0_25ck50 = 1.1 time = 255
.meas tran vdout0_25ck50 FIND v(dout0_25) AT=255.025n

* CHECK dout0_26 Vdout0_26ck50 = 0 time = 255
.meas tran vdout0_26ck50 FIND v(dout0_26) AT=255.025n

* CHECK dout0_27 Vdout0_27ck50 = 0 time = 255
.meas tran vdout0_27ck50 FIND v(dout0_27) AT=255.025n

* CHECK dout0_28 Vdout0_28ck50 = 1.1 time = 255
.meas tran vdout0_28ck50 FIND v(dout0_28) AT=255.025n

* CHECK dout0_29 Vdout0_29ck50 = 1.1 time = 255
.meas tran vdout0_29ck50 FIND v(dout0_29) AT=255.025n

* CHECK dout0_30 Vdout0_30ck50 = 1.1 time = 255
.meas tran vdout0_30ck50 FIND v(dout0_30) AT=255.025n

* CHECK dout0_31 Vdout0_31ck50 = 0 time = 255
.meas tran vdout0_31ck50 FIND v(dout0_31) AT=255.025n

* CHECK dout0_0 Vdout0_0ck51 = 1.1 time = 260
.meas tran vdout0_0ck51 FIND v(dout0_0) AT=260.025n

* CHECK dout0_1 Vdout0_1ck51 = 1.1 time = 260
.meas tran vdout0_1ck51 FIND v(dout0_1) AT=260.025n

* CHECK dout0_2 Vdout0_2ck51 = 0 time = 260
.meas tran vdout0_2ck51 FIND v(dout0_2) AT=260.025n

* CHECK dout0_3 Vdout0_3ck51 = 1.1 time = 260
.meas tran vdout0_3ck51 FIND v(dout0_3) AT=260.025n

* CHECK dout0_4 Vdout0_4ck51 = 0 time = 260
.meas tran vdout0_4ck51 FIND v(dout0_4) AT=260.025n

* CHECK dout0_5 Vdout0_5ck51 = 1.1 time = 260
.meas tran vdout0_5ck51 FIND v(dout0_5) AT=260.025n

* CHECK dout0_6 Vdout0_6ck51 = 0 time = 260
.meas tran vdout0_6ck51 FIND v(dout0_6) AT=260.025n

* CHECK dout0_7 Vdout0_7ck51 = 0 time = 260
.meas tran vdout0_7ck51 FIND v(dout0_7) AT=260.025n

* CHECK dout0_8 Vdout0_8ck51 = 0 time = 260
.meas tran vdout0_8ck51 FIND v(dout0_8) AT=260.025n

* CHECK dout0_9 Vdout0_9ck51 = 0 time = 260
.meas tran vdout0_9ck51 FIND v(dout0_9) AT=260.025n

* CHECK dout0_10 Vdout0_10ck51 = 0 time = 260
.meas tran vdout0_10ck51 FIND v(dout0_10) AT=260.025n

* CHECK dout0_11 Vdout0_11ck51 = 1.1 time = 260
.meas tran vdout0_11ck51 FIND v(dout0_11) AT=260.025n

* CHECK dout0_12 Vdout0_12ck51 = 1.1 time = 260
.meas tran vdout0_12ck51 FIND v(dout0_12) AT=260.025n

* CHECK dout0_13 Vdout0_13ck51 = 0 time = 260
.meas tran vdout0_13ck51 FIND v(dout0_13) AT=260.025n

* CHECK dout0_14 Vdout0_14ck51 = 0 time = 260
.meas tran vdout0_14ck51 FIND v(dout0_14) AT=260.025n

* CHECK dout0_15 Vdout0_15ck51 = 1.1 time = 260
.meas tran vdout0_15ck51 FIND v(dout0_15) AT=260.025n

* CHECK dout0_16 Vdout0_16ck51 = 1.1 time = 260
.meas tran vdout0_16ck51 FIND v(dout0_16) AT=260.025n

* CHECK dout0_17 Vdout0_17ck51 = 0 time = 260
.meas tran vdout0_17ck51 FIND v(dout0_17) AT=260.025n

* CHECK dout0_18 Vdout0_18ck51 = 0 time = 260
.meas tran vdout0_18ck51 FIND v(dout0_18) AT=260.025n

* CHECK dout0_19 Vdout0_19ck51 = 0 time = 260
.meas tran vdout0_19ck51 FIND v(dout0_19) AT=260.025n

* CHECK dout0_20 Vdout0_20ck51 = 1.1 time = 260
.meas tran vdout0_20ck51 FIND v(dout0_20) AT=260.025n

* CHECK dout0_21 Vdout0_21ck51 = 1.1 time = 260
.meas tran vdout0_21ck51 FIND v(dout0_21) AT=260.025n

* CHECK dout0_22 Vdout0_22ck51 = 0 time = 260
.meas tran vdout0_22ck51 FIND v(dout0_22) AT=260.025n

* CHECK dout0_23 Vdout0_23ck51 = 1.1 time = 260
.meas tran vdout0_23ck51 FIND v(dout0_23) AT=260.025n

* CHECK dout0_24 Vdout0_24ck51 = 0 time = 260
.meas tran vdout0_24ck51 FIND v(dout0_24) AT=260.025n

* CHECK dout0_25 Vdout0_25ck51 = 0 time = 260
.meas tran vdout0_25ck51 FIND v(dout0_25) AT=260.025n

* CHECK dout0_26 Vdout0_26ck51 = 0 time = 260
.meas tran vdout0_26ck51 FIND v(dout0_26) AT=260.025n

* CHECK dout0_27 Vdout0_27ck51 = 1.1 time = 260
.meas tran vdout0_27ck51 FIND v(dout0_27) AT=260.025n

* CHECK dout0_28 Vdout0_28ck51 = 1.1 time = 260
.meas tran vdout0_28ck51 FIND v(dout0_28) AT=260.025n

* CHECK dout0_29 Vdout0_29ck51 = 1.1 time = 260
.meas tran vdout0_29ck51 FIND v(dout0_29) AT=260.025n

* CHECK dout0_30 Vdout0_30ck51 = 1.1 time = 260
.meas tran vdout0_30ck51 FIND v(dout0_30) AT=260.025n

* CHECK dout0_31 Vdout0_31ck51 = 1.1 time = 260
.meas tran vdout0_31ck51 FIND v(dout0_31) AT=260.025n

* CHECK dout0_0 Vdout0_0ck53 = 1.1 time = 270
.meas tran vdout0_0ck53 FIND v(dout0_0) AT=270.025n

* CHECK dout0_1 Vdout0_1ck53 = 1.1 time = 270
.meas tran vdout0_1ck53 FIND v(dout0_1) AT=270.025n

* CHECK dout0_2 Vdout0_2ck53 = 0 time = 270
.meas tran vdout0_2ck53 FIND v(dout0_2) AT=270.025n

* CHECK dout0_3 Vdout0_3ck53 = 1.1 time = 270
.meas tran vdout0_3ck53 FIND v(dout0_3) AT=270.025n

* CHECK dout0_4 Vdout0_4ck53 = 0 time = 270
.meas tran vdout0_4ck53 FIND v(dout0_4) AT=270.025n

* CHECK dout0_5 Vdout0_5ck53 = 1.1 time = 270
.meas tran vdout0_5ck53 FIND v(dout0_5) AT=270.025n

* CHECK dout0_6 Vdout0_6ck53 = 0 time = 270
.meas tran vdout0_6ck53 FIND v(dout0_6) AT=270.025n

* CHECK dout0_7 Vdout0_7ck53 = 0 time = 270
.meas tran vdout0_7ck53 FIND v(dout0_7) AT=270.025n

* CHECK dout0_8 Vdout0_8ck53 = 0 time = 270
.meas tran vdout0_8ck53 FIND v(dout0_8) AT=270.025n

* CHECK dout0_9 Vdout0_9ck53 = 0 time = 270
.meas tran vdout0_9ck53 FIND v(dout0_9) AT=270.025n

* CHECK dout0_10 Vdout0_10ck53 = 0 time = 270
.meas tran vdout0_10ck53 FIND v(dout0_10) AT=270.025n

* CHECK dout0_11 Vdout0_11ck53 = 1.1 time = 270
.meas tran vdout0_11ck53 FIND v(dout0_11) AT=270.025n

* CHECK dout0_12 Vdout0_12ck53 = 1.1 time = 270
.meas tran vdout0_12ck53 FIND v(dout0_12) AT=270.025n

* CHECK dout0_13 Vdout0_13ck53 = 0 time = 270
.meas tran vdout0_13ck53 FIND v(dout0_13) AT=270.025n

* CHECK dout0_14 Vdout0_14ck53 = 0 time = 270
.meas tran vdout0_14ck53 FIND v(dout0_14) AT=270.025n

* CHECK dout0_15 Vdout0_15ck53 = 1.1 time = 270
.meas tran vdout0_15ck53 FIND v(dout0_15) AT=270.025n

* CHECK dout0_16 Vdout0_16ck53 = 1.1 time = 270
.meas tran vdout0_16ck53 FIND v(dout0_16) AT=270.025n

* CHECK dout0_17 Vdout0_17ck53 = 0 time = 270
.meas tran vdout0_17ck53 FIND v(dout0_17) AT=270.025n

* CHECK dout0_18 Vdout0_18ck53 = 0 time = 270
.meas tran vdout0_18ck53 FIND v(dout0_18) AT=270.025n

* CHECK dout0_19 Vdout0_19ck53 = 0 time = 270
.meas tran vdout0_19ck53 FIND v(dout0_19) AT=270.025n

* CHECK dout0_20 Vdout0_20ck53 = 1.1 time = 270
.meas tran vdout0_20ck53 FIND v(dout0_20) AT=270.025n

* CHECK dout0_21 Vdout0_21ck53 = 1.1 time = 270
.meas tran vdout0_21ck53 FIND v(dout0_21) AT=270.025n

* CHECK dout0_22 Vdout0_22ck53 = 0 time = 270
.meas tran vdout0_22ck53 FIND v(dout0_22) AT=270.025n

* CHECK dout0_23 Vdout0_23ck53 = 1.1 time = 270
.meas tran vdout0_23ck53 FIND v(dout0_23) AT=270.025n

* CHECK dout0_24 Vdout0_24ck53 = 0 time = 270
.meas tran vdout0_24ck53 FIND v(dout0_24) AT=270.025n

* CHECK dout0_25 Vdout0_25ck53 = 0 time = 270
.meas tran vdout0_25ck53 FIND v(dout0_25) AT=270.025n

* CHECK dout0_26 Vdout0_26ck53 = 0 time = 270
.meas tran vdout0_26ck53 FIND v(dout0_26) AT=270.025n

* CHECK dout0_27 Vdout0_27ck53 = 1.1 time = 270
.meas tran vdout0_27ck53 FIND v(dout0_27) AT=270.025n

* CHECK dout0_28 Vdout0_28ck53 = 1.1 time = 270
.meas tran vdout0_28ck53 FIND v(dout0_28) AT=270.025n

* CHECK dout0_29 Vdout0_29ck53 = 1.1 time = 270
.meas tran vdout0_29ck53 FIND v(dout0_29) AT=270.025n

* CHECK dout0_30 Vdout0_30ck53 = 1.1 time = 270
.meas tran vdout0_30ck53 FIND v(dout0_30) AT=270.025n

* CHECK dout0_31 Vdout0_31ck53 = 1.1 time = 270
.meas tran vdout0_31ck53 FIND v(dout0_31) AT=270.025n

* CHECK dout0_0 Vdout0_0ck54 = 1.1 time = 275
.meas tran vdout0_0ck54 FIND v(dout0_0) AT=275.025n

* CHECK dout0_1 Vdout0_1ck54 = 0 time = 275
.meas tran vdout0_1ck54 FIND v(dout0_1) AT=275.025n

* CHECK dout0_2 Vdout0_2ck54 = 0 time = 275
.meas tran vdout0_2ck54 FIND v(dout0_2) AT=275.025n

* CHECK dout0_3 Vdout0_3ck54 = 1.1 time = 275
.meas tran vdout0_3ck54 FIND v(dout0_3) AT=275.025n

* CHECK dout0_4 Vdout0_4ck54 = 1.1 time = 275
.meas tran vdout0_4ck54 FIND v(dout0_4) AT=275.025n

* CHECK dout0_5 Vdout0_5ck54 = 1.1 time = 275
.meas tran vdout0_5ck54 FIND v(dout0_5) AT=275.025n

* CHECK dout0_6 Vdout0_6ck54 = 1.1 time = 275
.meas tran vdout0_6ck54 FIND v(dout0_6) AT=275.025n

* CHECK dout0_7 Vdout0_7ck54 = 0 time = 275
.meas tran vdout0_7ck54 FIND v(dout0_7) AT=275.025n

* CHECK dout0_8 Vdout0_8ck54 = 0 time = 275
.meas tran vdout0_8ck54 FIND v(dout0_8) AT=275.025n

* CHECK dout0_9 Vdout0_9ck54 = 0 time = 275
.meas tran vdout0_9ck54 FIND v(dout0_9) AT=275.025n

* CHECK dout0_10 Vdout0_10ck54 = 1.1 time = 275
.meas tran vdout0_10ck54 FIND v(dout0_10) AT=275.025n

* CHECK dout0_11 Vdout0_11ck54 = 1.1 time = 275
.meas tran vdout0_11ck54 FIND v(dout0_11) AT=275.025n

* CHECK dout0_12 Vdout0_12ck54 = 1.1 time = 275
.meas tran vdout0_12ck54 FIND v(dout0_12) AT=275.025n

* CHECK dout0_13 Vdout0_13ck54 = 1.1 time = 275
.meas tran vdout0_13ck54 FIND v(dout0_13) AT=275.025n

* CHECK dout0_14 Vdout0_14ck54 = 1.1 time = 275
.meas tran vdout0_14ck54 FIND v(dout0_14) AT=275.025n

* CHECK dout0_15 Vdout0_15ck54 = 0 time = 275
.meas tran vdout0_15ck54 FIND v(dout0_15) AT=275.025n

* CHECK dout0_16 Vdout0_16ck54 = 0 time = 275
.meas tran vdout0_16ck54 FIND v(dout0_16) AT=275.025n

* CHECK dout0_17 Vdout0_17ck54 = 1.1 time = 275
.meas tran vdout0_17ck54 FIND v(dout0_17) AT=275.025n

* CHECK dout0_18 Vdout0_18ck54 = 1.1 time = 275
.meas tran vdout0_18ck54 FIND v(dout0_18) AT=275.025n

* CHECK dout0_19 Vdout0_19ck54 = 0 time = 275
.meas tran vdout0_19ck54 FIND v(dout0_19) AT=275.025n

* CHECK dout0_20 Vdout0_20ck54 = 0 time = 275
.meas tran vdout0_20ck54 FIND v(dout0_20) AT=275.025n

* CHECK dout0_21 Vdout0_21ck54 = 0 time = 275
.meas tran vdout0_21ck54 FIND v(dout0_21) AT=275.025n

* CHECK dout0_22 Vdout0_22ck54 = 1.1 time = 275
.meas tran vdout0_22ck54 FIND v(dout0_22) AT=275.025n

* CHECK dout0_23 Vdout0_23ck54 = 1.1 time = 275
.meas tran vdout0_23ck54 FIND v(dout0_23) AT=275.025n

* CHECK dout0_24 Vdout0_24ck54 = 0 time = 275
.meas tran vdout0_24ck54 FIND v(dout0_24) AT=275.025n

* CHECK dout0_25 Vdout0_25ck54 = 0 time = 275
.meas tran vdout0_25ck54 FIND v(dout0_25) AT=275.025n

* CHECK dout0_26 Vdout0_26ck54 = 1.1 time = 275
.meas tran vdout0_26ck54 FIND v(dout0_26) AT=275.025n

* CHECK dout0_27 Vdout0_27ck54 = 0 time = 275
.meas tran vdout0_27ck54 FIND v(dout0_27) AT=275.025n

* CHECK dout0_28 Vdout0_28ck54 = 1.1 time = 275
.meas tran vdout0_28ck54 FIND v(dout0_28) AT=275.025n

* CHECK dout0_29 Vdout0_29ck54 = 0 time = 275
.meas tran vdout0_29ck54 FIND v(dout0_29) AT=275.025n

* CHECK dout0_30 Vdout0_30ck54 = 0 time = 275
.meas tran vdout0_30ck54 FIND v(dout0_30) AT=275.025n

* CHECK dout0_31 Vdout0_31ck54 = 1.1 time = 275
.meas tran vdout0_31ck54 FIND v(dout0_31) AT=275.025n

* CHECK dout0_0 Vdout0_0ck56 = 1.1 time = 285
.meas tran vdout0_0ck56 FIND v(dout0_0) AT=285.025n

* CHECK dout0_1 Vdout0_1ck56 = 1.1 time = 285
.meas tran vdout0_1ck56 FIND v(dout0_1) AT=285.025n

* CHECK dout0_2 Vdout0_2ck56 = 0 time = 285
.meas tran vdout0_2ck56 FIND v(dout0_2) AT=285.025n

* CHECK dout0_3 Vdout0_3ck56 = 0 time = 285
.meas tran vdout0_3ck56 FIND v(dout0_3) AT=285.025n

* CHECK dout0_4 Vdout0_4ck56 = 1.1 time = 285
.meas tran vdout0_4ck56 FIND v(dout0_4) AT=285.025n

* CHECK dout0_5 Vdout0_5ck56 = 1.1 time = 285
.meas tran vdout0_5ck56 FIND v(dout0_5) AT=285.025n

* CHECK dout0_6 Vdout0_6ck56 = 1.1 time = 285
.meas tran vdout0_6ck56 FIND v(dout0_6) AT=285.025n

* CHECK dout0_7 Vdout0_7ck56 = 1.1 time = 285
.meas tran vdout0_7ck56 FIND v(dout0_7) AT=285.025n

* CHECK dout0_8 Vdout0_8ck56 = 1.1 time = 285
.meas tran vdout0_8ck56 FIND v(dout0_8) AT=285.025n

* CHECK dout0_9 Vdout0_9ck56 = 1.1 time = 285
.meas tran vdout0_9ck56 FIND v(dout0_9) AT=285.025n

* CHECK dout0_10 Vdout0_10ck56 = 0 time = 285
.meas tran vdout0_10ck56 FIND v(dout0_10) AT=285.025n

* CHECK dout0_11 Vdout0_11ck56 = 1.1 time = 285
.meas tran vdout0_11ck56 FIND v(dout0_11) AT=285.025n

* CHECK dout0_12 Vdout0_12ck56 = 1.1 time = 285
.meas tran vdout0_12ck56 FIND v(dout0_12) AT=285.025n

* CHECK dout0_13 Vdout0_13ck56 = 0 time = 285
.meas tran vdout0_13ck56 FIND v(dout0_13) AT=285.025n

* CHECK dout0_14 Vdout0_14ck56 = 0 time = 285
.meas tran vdout0_14ck56 FIND v(dout0_14) AT=285.025n

* CHECK dout0_15 Vdout0_15ck56 = 0 time = 285
.meas tran vdout0_15ck56 FIND v(dout0_15) AT=285.025n

* CHECK dout0_16 Vdout0_16ck56 = 0 time = 285
.meas tran vdout0_16ck56 FIND v(dout0_16) AT=285.025n

* CHECK dout0_17 Vdout0_17ck56 = 1.1 time = 285
.meas tran vdout0_17ck56 FIND v(dout0_17) AT=285.025n

* CHECK dout0_18 Vdout0_18ck56 = 1.1 time = 285
.meas tran vdout0_18ck56 FIND v(dout0_18) AT=285.025n

* CHECK dout0_19 Vdout0_19ck56 = 1.1 time = 285
.meas tran vdout0_19ck56 FIND v(dout0_19) AT=285.025n

* CHECK dout0_20 Vdout0_20ck56 = 1.1 time = 285
.meas tran vdout0_20ck56 FIND v(dout0_20) AT=285.025n

* CHECK dout0_21 Vdout0_21ck56 = 1.1 time = 285
.meas tran vdout0_21ck56 FIND v(dout0_21) AT=285.025n

* CHECK dout0_22 Vdout0_22ck56 = 1.1 time = 285
.meas tran vdout0_22ck56 FIND v(dout0_22) AT=285.025n

* CHECK dout0_23 Vdout0_23ck56 = 1.1 time = 285
.meas tran vdout0_23ck56 FIND v(dout0_23) AT=285.025n

* CHECK dout0_24 Vdout0_24ck56 = 0 time = 285
.meas tran vdout0_24ck56 FIND v(dout0_24) AT=285.025n

* CHECK dout0_25 Vdout0_25ck56 = 1.1 time = 285
.meas tran vdout0_25ck56 FIND v(dout0_25) AT=285.025n

* CHECK dout0_26 Vdout0_26ck56 = 1.1 time = 285
.meas tran vdout0_26ck56 FIND v(dout0_26) AT=285.025n

* CHECK dout0_27 Vdout0_27ck56 = 1.1 time = 285
.meas tran vdout0_27ck56 FIND v(dout0_27) AT=285.025n

* CHECK dout0_28 Vdout0_28ck56 = 0 time = 285
.meas tran vdout0_28ck56 FIND v(dout0_28) AT=285.025n

* CHECK dout0_29 Vdout0_29ck56 = 0 time = 285
.meas tran vdout0_29ck56 FIND v(dout0_29) AT=285.025n

* CHECK dout0_30 Vdout0_30ck56 = 1.1 time = 285
.meas tran vdout0_30ck56 FIND v(dout0_30) AT=285.025n

* CHECK dout0_31 Vdout0_31ck56 = 0 time = 285
.meas tran vdout0_31ck56 FIND v(dout0_31) AT=285.025n

* CHECK dout0_0 Vdout0_0ck57 = 1.1 time = 290
.meas tran vdout0_0ck57 FIND v(dout0_0) AT=290.025n

* CHECK dout0_1 Vdout0_1ck57 = 1.1 time = 290
.meas tran vdout0_1ck57 FIND v(dout0_1) AT=290.025n

* CHECK dout0_2 Vdout0_2ck57 = 0 time = 290
.meas tran vdout0_2ck57 FIND v(dout0_2) AT=290.025n

* CHECK dout0_3 Vdout0_3ck57 = 1.1 time = 290
.meas tran vdout0_3ck57 FIND v(dout0_3) AT=290.025n

* CHECK dout0_4 Vdout0_4ck57 = 0 time = 290
.meas tran vdout0_4ck57 FIND v(dout0_4) AT=290.025n

* CHECK dout0_5 Vdout0_5ck57 = 1.1 time = 290
.meas tran vdout0_5ck57 FIND v(dout0_5) AT=290.025n

* CHECK dout0_6 Vdout0_6ck57 = 0 time = 290
.meas tran vdout0_6ck57 FIND v(dout0_6) AT=290.025n

* CHECK dout0_7 Vdout0_7ck57 = 0 time = 290
.meas tran vdout0_7ck57 FIND v(dout0_7) AT=290.025n

* CHECK dout0_8 Vdout0_8ck57 = 0 time = 290
.meas tran vdout0_8ck57 FIND v(dout0_8) AT=290.025n

* CHECK dout0_9 Vdout0_9ck57 = 0 time = 290
.meas tran vdout0_9ck57 FIND v(dout0_9) AT=290.025n

* CHECK dout0_10 Vdout0_10ck57 = 0 time = 290
.meas tran vdout0_10ck57 FIND v(dout0_10) AT=290.025n

* CHECK dout0_11 Vdout0_11ck57 = 1.1 time = 290
.meas tran vdout0_11ck57 FIND v(dout0_11) AT=290.025n

* CHECK dout0_12 Vdout0_12ck57 = 1.1 time = 290
.meas tran vdout0_12ck57 FIND v(dout0_12) AT=290.025n

* CHECK dout0_13 Vdout0_13ck57 = 0 time = 290
.meas tran vdout0_13ck57 FIND v(dout0_13) AT=290.025n

* CHECK dout0_14 Vdout0_14ck57 = 0 time = 290
.meas tran vdout0_14ck57 FIND v(dout0_14) AT=290.025n

* CHECK dout0_15 Vdout0_15ck57 = 1.1 time = 290
.meas tran vdout0_15ck57 FIND v(dout0_15) AT=290.025n

* CHECK dout0_16 Vdout0_16ck57 = 1.1 time = 290
.meas tran vdout0_16ck57 FIND v(dout0_16) AT=290.025n

* CHECK dout0_17 Vdout0_17ck57 = 0 time = 290
.meas tran vdout0_17ck57 FIND v(dout0_17) AT=290.025n

* CHECK dout0_18 Vdout0_18ck57 = 0 time = 290
.meas tran vdout0_18ck57 FIND v(dout0_18) AT=290.025n

* CHECK dout0_19 Vdout0_19ck57 = 0 time = 290
.meas tran vdout0_19ck57 FIND v(dout0_19) AT=290.025n

* CHECK dout0_20 Vdout0_20ck57 = 1.1 time = 290
.meas tran vdout0_20ck57 FIND v(dout0_20) AT=290.025n

* CHECK dout0_21 Vdout0_21ck57 = 1.1 time = 290
.meas tran vdout0_21ck57 FIND v(dout0_21) AT=290.025n

* CHECK dout0_22 Vdout0_22ck57 = 0 time = 290
.meas tran vdout0_22ck57 FIND v(dout0_22) AT=290.025n

* CHECK dout0_23 Vdout0_23ck57 = 1.1 time = 290
.meas tran vdout0_23ck57 FIND v(dout0_23) AT=290.025n

* CHECK dout0_24 Vdout0_24ck57 = 0 time = 290
.meas tran vdout0_24ck57 FIND v(dout0_24) AT=290.025n

* CHECK dout0_25 Vdout0_25ck57 = 0 time = 290
.meas tran vdout0_25ck57 FIND v(dout0_25) AT=290.025n

* CHECK dout0_26 Vdout0_26ck57 = 0 time = 290
.meas tran vdout0_26ck57 FIND v(dout0_26) AT=290.025n

* CHECK dout0_27 Vdout0_27ck57 = 1.1 time = 290
.meas tran vdout0_27ck57 FIND v(dout0_27) AT=290.025n

* CHECK dout0_28 Vdout0_28ck57 = 1.1 time = 290
.meas tran vdout0_28ck57 FIND v(dout0_28) AT=290.025n

* CHECK dout0_29 Vdout0_29ck57 = 1.1 time = 290
.meas tran vdout0_29ck57 FIND v(dout0_29) AT=290.025n

* CHECK dout0_30 Vdout0_30ck57 = 1.1 time = 290
.meas tran vdout0_30ck57 FIND v(dout0_30) AT=290.025n

* CHECK dout0_31 Vdout0_31ck57 = 1.1 time = 290
.meas tran vdout0_31ck57 FIND v(dout0_31) AT=290.025n

* CHECK dout0_0 Vdout0_0ck61 = 1.1 time = 310
.meas tran vdout0_0ck61 FIND v(dout0_0) AT=310.025n

* CHECK dout0_1 Vdout0_1ck61 = 1.1 time = 310
.meas tran vdout0_1ck61 FIND v(dout0_1) AT=310.025n

* CHECK dout0_2 Vdout0_2ck61 = 0 time = 310
.meas tran vdout0_2ck61 FIND v(dout0_2) AT=310.025n

* CHECK dout0_3 Vdout0_3ck61 = 0 time = 310
.meas tran vdout0_3ck61 FIND v(dout0_3) AT=310.025n

* CHECK dout0_4 Vdout0_4ck61 = 1.1 time = 310
.meas tran vdout0_4ck61 FIND v(dout0_4) AT=310.025n

* CHECK dout0_5 Vdout0_5ck61 = 1.1 time = 310
.meas tran vdout0_5ck61 FIND v(dout0_5) AT=310.025n

* CHECK dout0_6 Vdout0_6ck61 = 1.1 time = 310
.meas tran vdout0_6ck61 FIND v(dout0_6) AT=310.025n

* CHECK dout0_7 Vdout0_7ck61 = 1.1 time = 310
.meas tran vdout0_7ck61 FIND v(dout0_7) AT=310.025n

* CHECK dout0_8 Vdout0_8ck61 = 1.1 time = 310
.meas tran vdout0_8ck61 FIND v(dout0_8) AT=310.025n

* CHECK dout0_9 Vdout0_9ck61 = 1.1 time = 310
.meas tran vdout0_9ck61 FIND v(dout0_9) AT=310.025n

* CHECK dout0_10 Vdout0_10ck61 = 0 time = 310
.meas tran vdout0_10ck61 FIND v(dout0_10) AT=310.025n

* CHECK dout0_11 Vdout0_11ck61 = 1.1 time = 310
.meas tran vdout0_11ck61 FIND v(dout0_11) AT=310.025n

* CHECK dout0_12 Vdout0_12ck61 = 1.1 time = 310
.meas tran vdout0_12ck61 FIND v(dout0_12) AT=310.025n

* CHECK dout0_13 Vdout0_13ck61 = 0 time = 310
.meas tran vdout0_13ck61 FIND v(dout0_13) AT=310.025n

* CHECK dout0_14 Vdout0_14ck61 = 0 time = 310
.meas tran vdout0_14ck61 FIND v(dout0_14) AT=310.025n

* CHECK dout0_15 Vdout0_15ck61 = 0 time = 310
.meas tran vdout0_15ck61 FIND v(dout0_15) AT=310.025n

* CHECK dout0_16 Vdout0_16ck61 = 0 time = 310
.meas tran vdout0_16ck61 FIND v(dout0_16) AT=310.025n

* CHECK dout0_17 Vdout0_17ck61 = 1.1 time = 310
.meas tran vdout0_17ck61 FIND v(dout0_17) AT=310.025n

* CHECK dout0_18 Vdout0_18ck61 = 1.1 time = 310
.meas tran vdout0_18ck61 FIND v(dout0_18) AT=310.025n

* CHECK dout0_19 Vdout0_19ck61 = 1.1 time = 310
.meas tran vdout0_19ck61 FIND v(dout0_19) AT=310.025n

* CHECK dout0_20 Vdout0_20ck61 = 1.1 time = 310
.meas tran vdout0_20ck61 FIND v(dout0_20) AT=310.025n

* CHECK dout0_21 Vdout0_21ck61 = 1.1 time = 310
.meas tran vdout0_21ck61 FIND v(dout0_21) AT=310.025n

* CHECK dout0_22 Vdout0_22ck61 = 1.1 time = 310
.meas tran vdout0_22ck61 FIND v(dout0_22) AT=310.025n

* CHECK dout0_23 Vdout0_23ck61 = 1.1 time = 310
.meas tran vdout0_23ck61 FIND v(dout0_23) AT=310.025n

* CHECK dout0_24 Vdout0_24ck61 = 0 time = 310
.meas tran vdout0_24ck61 FIND v(dout0_24) AT=310.025n

* CHECK dout0_25 Vdout0_25ck61 = 1.1 time = 310
.meas tran vdout0_25ck61 FIND v(dout0_25) AT=310.025n

* CHECK dout0_26 Vdout0_26ck61 = 1.1 time = 310
.meas tran vdout0_26ck61 FIND v(dout0_26) AT=310.025n

* CHECK dout0_27 Vdout0_27ck61 = 1.1 time = 310
.meas tran vdout0_27ck61 FIND v(dout0_27) AT=310.025n

* CHECK dout0_28 Vdout0_28ck61 = 0 time = 310
.meas tran vdout0_28ck61 FIND v(dout0_28) AT=310.025n

* CHECK dout0_29 Vdout0_29ck61 = 0 time = 310
.meas tran vdout0_29ck61 FIND v(dout0_29) AT=310.025n

* CHECK dout0_30 Vdout0_30ck61 = 1.1 time = 310
.meas tran vdout0_30ck61 FIND v(dout0_30) AT=310.025n

* CHECK dout0_31 Vdout0_31ck61 = 0 time = 310
.meas tran vdout0_31ck61 FIND v(dout0_31) AT=310.025n

* CHECK dout0_0 Vdout0_0ck62 = 0 time = 315
.meas tran vdout0_0ck62 FIND v(dout0_0) AT=315.025n

* CHECK dout0_1 Vdout0_1ck62 = 1.1 time = 315
.meas tran vdout0_1ck62 FIND v(dout0_1) AT=315.025n

* CHECK dout0_2 Vdout0_2ck62 = 0 time = 315
.meas tran vdout0_2ck62 FIND v(dout0_2) AT=315.025n

* CHECK dout0_3 Vdout0_3ck62 = 1.1 time = 315
.meas tran vdout0_3ck62 FIND v(dout0_3) AT=315.025n

* CHECK dout0_4 Vdout0_4ck62 = 1.1 time = 315
.meas tran vdout0_4ck62 FIND v(dout0_4) AT=315.025n

* CHECK dout0_5 Vdout0_5ck62 = 0 time = 315
.meas tran vdout0_5ck62 FIND v(dout0_5) AT=315.025n

* CHECK dout0_6 Vdout0_6ck62 = 1.1 time = 315
.meas tran vdout0_6ck62 FIND v(dout0_6) AT=315.025n

* CHECK dout0_7 Vdout0_7ck62 = 1.1 time = 315
.meas tran vdout0_7ck62 FIND v(dout0_7) AT=315.025n

* CHECK dout0_8 Vdout0_8ck62 = 0 time = 315
.meas tran vdout0_8ck62 FIND v(dout0_8) AT=315.025n

* CHECK dout0_9 Vdout0_9ck62 = 0 time = 315
.meas tran vdout0_9ck62 FIND v(dout0_9) AT=315.025n

* CHECK dout0_10 Vdout0_10ck62 = 0 time = 315
.meas tran vdout0_10ck62 FIND v(dout0_10) AT=315.025n

* CHECK dout0_11 Vdout0_11ck62 = 0 time = 315
.meas tran vdout0_11ck62 FIND v(dout0_11) AT=315.025n

* CHECK dout0_12 Vdout0_12ck62 = 0 time = 315
.meas tran vdout0_12ck62 FIND v(dout0_12) AT=315.025n

* CHECK dout0_13 Vdout0_13ck62 = 0 time = 315
.meas tran vdout0_13ck62 FIND v(dout0_13) AT=315.025n

* CHECK dout0_14 Vdout0_14ck62 = 1.1 time = 315
.meas tran vdout0_14ck62 FIND v(dout0_14) AT=315.025n

* CHECK dout0_15 Vdout0_15ck62 = 1.1 time = 315
.meas tran vdout0_15ck62 FIND v(dout0_15) AT=315.025n

* CHECK dout0_16 Vdout0_16ck62 = 1.1 time = 315
.meas tran vdout0_16ck62 FIND v(dout0_16) AT=315.025n

* CHECK dout0_17 Vdout0_17ck62 = 0 time = 315
.meas tran vdout0_17ck62 FIND v(dout0_17) AT=315.025n

* CHECK dout0_18 Vdout0_18ck62 = 0 time = 315
.meas tran vdout0_18ck62 FIND v(dout0_18) AT=315.025n

* CHECK dout0_19 Vdout0_19ck62 = 0 time = 315
.meas tran vdout0_19ck62 FIND v(dout0_19) AT=315.025n

* CHECK dout0_20 Vdout0_20ck62 = 1.1 time = 315
.meas tran vdout0_20ck62 FIND v(dout0_20) AT=315.025n

* CHECK dout0_21 Vdout0_21ck62 = 0 time = 315
.meas tran vdout0_21ck62 FIND v(dout0_21) AT=315.025n

* CHECK dout0_22 Vdout0_22ck62 = 1.1 time = 315
.meas tran vdout0_22ck62 FIND v(dout0_22) AT=315.025n

* CHECK dout0_23 Vdout0_23ck62 = 0 time = 315
.meas tran vdout0_23ck62 FIND v(dout0_23) AT=315.025n

* CHECK dout0_24 Vdout0_24ck62 = 0 time = 315
.meas tran vdout0_24ck62 FIND v(dout0_24) AT=315.025n

* CHECK dout0_25 Vdout0_25ck62 = 0 time = 315
.meas tran vdout0_25ck62 FIND v(dout0_25) AT=315.025n

* CHECK dout0_26 Vdout0_26ck62 = 1.1 time = 315
.meas tran vdout0_26ck62 FIND v(dout0_26) AT=315.025n

* CHECK dout0_27 Vdout0_27ck62 = 1.1 time = 315
.meas tran vdout0_27ck62 FIND v(dout0_27) AT=315.025n

* CHECK dout0_28 Vdout0_28ck62 = 0 time = 315
.meas tran vdout0_28ck62 FIND v(dout0_28) AT=315.025n

* CHECK dout0_29 Vdout0_29ck62 = 1.1 time = 315
.meas tran vdout0_29ck62 FIND v(dout0_29) AT=315.025n

* CHECK dout0_30 Vdout0_30ck62 = 0 time = 315
.meas tran vdout0_30ck62 FIND v(dout0_30) AT=315.025n

* CHECK dout0_31 Vdout0_31ck62 = 0 time = 315
.meas tran vdout0_31ck62 FIND v(dout0_31) AT=315.025n

* CHECK dout0_0 Vdout0_0ck66 = 0 time = 335
.meas tran vdout0_0ck66 FIND v(dout0_0) AT=335.025n

* CHECK dout0_1 Vdout0_1ck66 = 1.1 time = 335
.meas tran vdout0_1ck66 FIND v(dout0_1) AT=335.025n

* CHECK dout0_2 Vdout0_2ck66 = 0 time = 335
.meas tran vdout0_2ck66 FIND v(dout0_2) AT=335.025n

* CHECK dout0_3 Vdout0_3ck66 = 1.1 time = 335
.meas tran vdout0_3ck66 FIND v(dout0_3) AT=335.025n

* CHECK dout0_4 Vdout0_4ck66 = 1.1 time = 335
.meas tran vdout0_4ck66 FIND v(dout0_4) AT=335.025n

* CHECK dout0_5 Vdout0_5ck66 = 0 time = 335
.meas tran vdout0_5ck66 FIND v(dout0_5) AT=335.025n

* CHECK dout0_6 Vdout0_6ck66 = 1.1 time = 335
.meas tran vdout0_6ck66 FIND v(dout0_6) AT=335.025n

* CHECK dout0_7 Vdout0_7ck66 = 1.1 time = 335
.meas tran vdout0_7ck66 FIND v(dout0_7) AT=335.025n

* CHECK dout0_8 Vdout0_8ck66 = 0 time = 335
.meas tran vdout0_8ck66 FIND v(dout0_8) AT=335.025n

* CHECK dout0_9 Vdout0_9ck66 = 0 time = 335
.meas tran vdout0_9ck66 FIND v(dout0_9) AT=335.025n

* CHECK dout0_10 Vdout0_10ck66 = 0 time = 335
.meas tran vdout0_10ck66 FIND v(dout0_10) AT=335.025n

* CHECK dout0_11 Vdout0_11ck66 = 0 time = 335
.meas tran vdout0_11ck66 FIND v(dout0_11) AT=335.025n

* CHECK dout0_12 Vdout0_12ck66 = 0 time = 335
.meas tran vdout0_12ck66 FIND v(dout0_12) AT=335.025n

* CHECK dout0_13 Vdout0_13ck66 = 0 time = 335
.meas tran vdout0_13ck66 FIND v(dout0_13) AT=335.025n

* CHECK dout0_14 Vdout0_14ck66 = 1.1 time = 335
.meas tran vdout0_14ck66 FIND v(dout0_14) AT=335.025n

* CHECK dout0_15 Vdout0_15ck66 = 1.1 time = 335
.meas tran vdout0_15ck66 FIND v(dout0_15) AT=335.025n

* CHECK dout0_16 Vdout0_16ck66 = 1.1 time = 335
.meas tran vdout0_16ck66 FIND v(dout0_16) AT=335.025n

* CHECK dout0_17 Vdout0_17ck66 = 0 time = 335
.meas tran vdout0_17ck66 FIND v(dout0_17) AT=335.025n

* CHECK dout0_18 Vdout0_18ck66 = 0 time = 335
.meas tran vdout0_18ck66 FIND v(dout0_18) AT=335.025n

* CHECK dout0_19 Vdout0_19ck66 = 0 time = 335
.meas tran vdout0_19ck66 FIND v(dout0_19) AT=335.025n

* CHECK dout0_20 Vdout0_20ck66 = 1.1 time = 335
.meas tran vdout0_20ck66 FIND v(dout0_20) AT=335.025n

* CHECK dout0_21 Vdout0_21ck66 = 0 time = 335
.meas tran vdout0_21ck66 FIND v(dout0_21) AT=335.025n

* CHECK dout0_22 Vdout0_22ck66 = 1.1 time = 335
.meas tran vdout0_22ck66 FIND v(dout0_22) AT=335.025n

* CHECK dout0_23 Vdout0_23ck66 = 0 time = 335
.meas tran vdout0_23ck66 FIND v(dout0_23) AT=335.025n

* CHECK dout0_24 Vdout0_24ck66 = 0 time = 335
.meas tran vdout0_24ck66 FIND v(dout0_24) AT=335.025n

* CHECK dout0_25 Vdout0_25ck66 = 0 time = 335
.meas tran vdout0_25ck66 FIND v(dout0_25) AT=335.025n

* CHECK dout0_26 Vdout0_26ck66 = 1.1 time = 335
.meas tran vdout0_26ck66 FIND v(dout0_26) AT=335.025n

* CHECK dout0_27 Vdout0_27ck66 = 1.1 time = 335
.meas tran vdout0_27ck66 FIND v(dout0_27) AT=335.025n

* CHECK dout0_28 Vdout0_28ck66 = 0 time = 335
.meas tran vdout0_28ck66 FIND v(dout0_28) AT=335.025n

* CHECK dout0_29 Vdout0_29ck66 = 1.1 time = 335
.meas tran vdout0_29ck66 FIND v(dout0_29) AT=335.025n

* CHECK dout0_30 Vdout0_30ck66 = 0 time = 335
.meas tran vdout0_30ck66 FIND v(dout0_30) AT=335.025n

* CHECK dout0_31 Vdout0_31ck66 = 0 time = 335
.meas tran vdout0_31ck66 FIND v(dout0_31) AT=335.025n

* CHECK dout0_0 Vdout0_0ck69 = 0 time = 350
.meas tran vdout0_0ck69 FIND v(dout0_0) AT=350.025n

* CHECK dout0_1 Vdout0_1ck69 = 1.1 time = 350
.meas tran vdout0_1ck69 FIND v(dout0_1) AT=350.025n

* CHECK dout0_2 Vdout0_2ck69 = 0 time = 350
.meas tran vdout0_2ck69 FIND v(dout0_2) AT=350.025n

* CHECK dout0_3 Vdout0_3ck69 = 1.1 time = 350
.meas tran vdout0_3ck69 FIND v(dout0_3) AT=350.025n

* CHECK dout0_4 Vdout0_4ck69 = 1.1 time = 350
.meas tran vdout0_4ck69 FIND v(dout0_4) AT=350.025n

* CHECK dout0_5 Vdout0_5ck69 = 0 time = 350
.meas tran vdout0_5ck69 FIND v(dout0_5) AT=350.025n

* CHECK dout0_6 Vdout0_6ck69 = 1.1 time = 350
.meas tran vdout0_6ck69 FIND v(dout0_6) AT=350.025n

* CHECK dout0_7 Vdout0_7ck69 = 1.1 time = 350
.meas tran vdout0_7ck69 FIND v(dout0_7) AT=350.025n

* CHECK dout0_8 Vdout0_8ck69 = 0 time = 350
.meas tran vdout0_8ck69 FIND v(dout0_8) AT=350.025n

* CHECK dout0_9 Vdout0_9ck69 = 0 time = 350
.meas tran vdout0_9ck69 FIND v(dout0_9) AT=350.025n

* CHECK dout0_10 Vdout0_10ck69 = 0 time = 350
.meas tran vdout0_10ck69 FIND v(dout0_10) AT=350.025n

* CHECK dout0_11 Vdout0_11ck69 = 0 time = 350
.meas tran vdout0_11ck69 FIND v(dout0_11) AT=350.025n

* CHECK dout0_12 Vdout0_12ck69 = 0 time = 350
.meas tran vdout0_12ck69 FIND v(dout0_12) AT=350.025n

* CHECK dout0_13 Vdout0_13ck69 = 0 time = 350
.meas tran vdout0_13ck69 FIND v(dout0_13) AT=350.025n

* CHECK dout0_14 Vdout0_14ck69 = 1.1 time = 350
.meas tran vdout0_14ck69 FIND v(dout0_14) AT=350.025n

* CHECK dout0_15 Vdout0_15ck69 = 1.1 time = 350
.meas tran vdout0_15ck69 FIND v(dout0_15) AT=350.025n

* CHECK dout0_16 Vdout0_16ck69 = 1.1 time = 350
.meas tran vdout0_16ck69 FIND v(dout0_16) AT=350.025n

* CHECK dout0_17 Vdout0_17ck69 = 0 time = 350
.meas tran vdout0_17ck69 FIND v(dout0_17) AT=350.025n

* CHECK dout0_18 Vdout0_18ck69 = 0 time = 350
.meas tran vdout0_18ck69 FIND v(dout0_18) AT=350.025n

* CHECK dout0_19 Vdout0_19ck69 = 0 time = 350
.meas tran vdout0_19ck69 FIND v(dout0_19) AT=350.025n

* CHECK dout0_20 Vdout0_20ck69 = 1.1 time = 350
.meas tran vdout0_20ck69 FIND v(dout0_20) AT=350.025n

* CHECK dout0_21 Vdout0_21ck69 = 0 time = 350
.meas tran vdout0_21ck69 FIND v(dout0_21) AT=350.025n

* CHECK dout0_22 Vdout0_22ck69 = 1.1 time = 350
.meas tran vdout0_22ck69 FIND v(dout0_22) AT=350.025n

* CHECK dout0_23 Vdout0_23ck69 = 0 time = 350
.meas tran vdout0_23ck69 FIND v(dout0_23) AT=350.025n

* CHECK dout0_24 Vdout0_24ck69 = 0 time = 350
.meas tran vdout0_24ck69 FIND v(dout0_24) AT=350.025n

* CHECK dout0_25 Vdout0_25ck69 = 0 time = 350
.meas tran vdout0_25ck69 FIND v(dout0_25) AT=350.025n

* CHECK dout0_26 Vdout0_26ck69 = 1.1 time = 350
.meas tran vdout0_26ck69 FIND v(dout0_26) AT=350.025n

* CHECK dout0_27 Vdout0_27ck69 = 1.1 time = 350
.meas tran vdout0_27ck69 FIND v(dout0_27) AT=350.025n

* CHECK dout0_28 Vdout0_28ck69 = 0 time = 350
.meas tran vdout0_28ck69 FIND v(dout0_28) AT=350.025n

* CHECK dout0_29 Vdout0_29ck69 = 1.1 time = 350
.meas tran vdout0_29ck69 FIND v(dout0_29) AT=350.025n

* CHECK dout0_30 Vdout0_30ck69 = 0 time = 350
.meas tran vdout0_30ck69 FIND v(dout0_30) AT=350.025n

* CHECK dout0_31 Vdout0_31ck69 = 0 time = 350
.meas tran vdout0_31ck69 FIND v(dout0_31) AT=350.025n

* CHECK dout0_0 Vdout0_0ck74 = 0 time = 375
.meas tran vdout0_0ck74 FIND v(dout0_0) AT=375.025n

* CHECK dout0_1 Vdout0_1ck74 = 1.1 time = 375
.meas tran vdout0_1ck74 FIND v(dout0_1) AT=375.025n

* CHECK dout0_2 Vdout0_2ck74 = 1.1 time = 375
.meas tran vdout0_2ck74 FIND v(dout0_2) AT=375.025n

* CHECK dout0_3 Vdout0_3ck74 = 0 time = 375
.meas tran vdout0_3ck74 FIND v(dout0_3) AT=375.025n

* CHECK dout0_4 Vdout0_4ck74 = 0 time = 375
.meas tran vdout0_4ck74 FIND v(dout0_4) AT=375.025n

* CHECK dout0_5 Vdout0_5ck74 = 1.1 time = 375
.meas tran vdout0_5ck74 FIND v(dout0_5) AT=375.025n

* CHECK dout0_6 Vdout0_6ck74 = 0 time = 375
.meas tran vdout0_6ck74 FIND v(dout0_6) AT=375.025n

* CHECK dout0_7 Vdout0_7ck74 = 0 time = 375
.meas tran vdout0_7ck74 FIND v(dout0_7) AT=375.025n

* CHECK dout0_8 Vdout0_8ck74 = 1.1 time = 375
.meas tran vdout0_8ck74 FIND v(dout0_8) AT=375.025n

* CHECK dout0_9 Vdout0_9ck74 = 1.1 time = 375
.meas tran vdout0_9ck74 FIND v(dout0_9) AT=375.025n

* CHECK dout0_10 Vdout0_10ck74 = 0 time = 375
.meas tran vdout0_10ck74 FIND v(dout0_10) AT=375.025n

* CHECK dout0_11 Vdout0_11ck74 = 1.1 time = 375
.meas tran vdout0_11ck74 FIND v(dout0_11) AT=375.025n

* CHECK dout0_12 Vdout0_12ck74 = 0 time = 375
.meas tran vdout0_12ck74 FIND v(dout0_12) AT=375.025n

* CHECK dout0_13 Vdout0_13ck74 = 1.1 time = 375
.meas tran vdout0_13ck74 FIND v(dout0_13) AT=375.025n

* CHECK dout0_14 Vdout0_14ck74 = 0 time = 375
.meas tran vdout0_14ck74 FIND v(dout0_14) AT=375.025n

* CHECK dout0_15 Vdout0_15ck74 = 0 time = 375
.meas tran vdout0_15ck74 FIND v(dout0_15) AT=375.025n

* CHECK dout0_16 Vdout0_16ck74 = 1.1 time = 375
.meas tran vdout0_16ck74 FIND v(dout0_16) AT=375.025n

* CHECK dout0_17 Vdout0_17ck74 = 0 time = 375
.meas tran vdout0_17ck74 FIND v(dout0_17) AT=375.025n

* CHECK dout0_18 Vdout0_18ck74 = 1.1 time = 375
.meas tran vdout0_18ck74 FIND v(dout0_18) AT=375.025n

* CHECK dout0_19 Vdout0_19ck74 = 0 time = 375
.meas tran vdout0_19ck74 FIND v(dout0_19) AT=375.025n

* CHECK dout0_20 Vdout0_20ck74 = 0 time = 375
.meas tran vdout0_20ck74 FIND v(dout0_20) AT=375.025n

* CHECK dout0_21 Vdout0_21ck74 = 1.1 time = 375
.meas tran vdout0_21ck74 FIND v(dout0_21) AT=375.025n

* CHECK dout0_22 Vdout0_22ck74 = 1.1 time = 375
.meas tran vdout0_22ck74 FIND v(dout0_22) AT=375.025n

* CHECK dout0_23 Vdout0_23ck74 = 0 time = 375
.meas tran vdout0_23ck74 FIND v(dout0_23) AT=375.025n

* CHECK dout0_24 Vdout0_24ck74 = 1.1 time = 375
.meas tran vdout0_24ck74 FIND v(dout0_24) AT=375.025n

* CHECK dout0_25 Vdout0_25ck74 = 0 time = 375
.meas tran vdout0_25ck74 FIND v(dout0_25) AT=375.025n

* CHECK dout0_26 Vdout0_26ck74 = 0 time = 375
.meas tran vdout0_26ck74 FIND v(dout0_26) AT=375.025n

* CHECK dout0_27 Vdout0_27ck74 = 1.1 time = 375
.meas tran vdout0_27ck74 FIND v(dout0_27) AT=375.025n

* CHECK dout0_28 Vdout0_28ck74 = 1.1 time = 375
.meas tran vdout0_28ck74 FIND v(dout0_28) AT=375.025n

* CHECK dout0_29 Vdout0_29ck74 = 1.1 time = 375
.meas tran vdout0_29ck74 FIND v(dout0_29) AT=375.025n

* CHECK dout0_30 Vdout0_30ck74 = 0 time = 375
.meas tran vdout0_30ck74 FIND v(dout0_30) AT=375.025n

* CHECK dout0_31 Vdout0_31ck74 = 1.1 time = 375
.meas tran vdout0_31ck74 FIND v(dout0_31) AT=375.025n

* CHECK dout0_0 Vdout0_0ck77 = 1.1 time = 390
.meas tran vdout0_0ck77 FIND v(dout0_0) AT=390.025n

* CHECK dout0_1 Vdout0_1ck77 = 0 time = 390
.meas tran vdout0_1ck77 FIND v(dout0_1) AT=390.025n

* CHECK dout0_2 Vdout0_2ck77 = 1.1 time = 390
.meas tran vdout0_2ck77 FIND v(dout0_2) AT=390.025n

* CHECK dout0_3 Vdout0_3ck77 = 1.1 time = 390
.meas tran vdout0_3ck77 FIND v(dout0_3) AT=390.025n

* CHECK dout0_4 Vdout0_4ck77 = 0 time = 390
.meas tran vdout0_4ck77 FIND v(dout0_4) AT=390.025n

* CHECK dout0_5 Vdout0_5ck77 = 1.1 time = 390
.meas tran vdout0_5ck77 FIND v(dout0_5) AT=390.025n

* CHECK dout0_6 Vdout0_6ck77 = 1.1 time = 390
.meas tran vdout0_6ck77 FIND v(dout0_6) AT=390.025n

* CHECK dout0_7 Vdout0_7ck77 = 1.1 time = 390
.meas tran vdout0_7ck77 FIND v(dout0_7) AT=390.025n

* CHECK dout0_8 Vdout0_8ck77 = 0 time = 390
.meas tran vdout0_8ck77 FIND v(dout0_8) AT=390.025n

* CHECK dout0_9 Vdout0_9ck77 = 0 time = 390
.meas tran vdout0_9ck77 FIND v(dout0_9) AT=390.025n

* CHECK dout0_10 Vdout0_10ck77 = 0 time = 390
.meas tran vdout0_10ck77 FIND v(dout0_10) AT=390.025n

* CHECK dout0_11 Vdout0_11ck77 = 1.1 time = 390
.meas tran vdout0_11ck77 FIND v(dout0_11) AT=390.025n

* CHECK dout0_12 Vdout0_12ck77 = 1.1 time = 390
.meas tran vdout0_12ck77 FIND v(dout0_12) AT=390.025n

* CHECK dout0_13 Vdout0_13ck77 = 1.1 time = 390
.meas tran vdout0_13ck77 FIND v(dout0_13) AT=390.025n

* CHECK dout0_14 Vdout0_14ck77 = 1.1 time = 390
.meas tran vdout0_14ck77 FIND v(dout0_14) AT=390.025n

* CHECK dout0_15 Vdout0_15ck77 = 0 time = 390
.meas tran vdout0_15ck77 FIND v(dout0_15) AT=390.025n

* CHECK dout0_16 Vdout0_16ck77 = 1.1 time = 390
.meas tran vdout0_16ck77 FIND v(dout0_16) AT=390.025n

* CHECK dout0_17 Vdout0_17ck77 = 0 time = 390
.meas tran vdout0_17ck77 FIND v(dout0_17) AT=390.025n

* CHECK dout0_18 Vdout0_18ck77 = 1.1 time = 390
.meas tran vdout0_18ck77 FIND v(dout0_18) AT=390.025n

* CHECK dout0_19 Vdout0_19ck77 = 1.1 time = 390
.meas tran vdout0_19ck77 FIND v(dout0_19) AT=390.025n

* CHECK dout0_20 Vdout0_20ck77 = 0 time = 390
.meas tran vdout0_20ck77 FIND v(dout0_20) AT=390.025n

* CHECK dout0_21 Vdout0_21ck77 = 1.1 time = 390
.meas tran vdout0_21ck77 FIND v(dout0_21) AT=390.025n

* CHECK dout0_22 Vdout0_22ck77 = 1.1 time = 390
.meas tran vdout0_22ck77 FIND v(dout0_22) AT=390.025n

* CHECK dout0_23 Vdout0_23ck77 = 1.1 time = 390
.meas tran vdout0_23ck77 FIND v(dout0_23) AT=390.025n

* CHECK dout0_24 Vdout0_24ck77 = 1.1 time = 390
.meas tran vdout0_24ck77 FIND v(dout0_24) AT=390.025n

* CHECK dout0_25 Vdout0_25ck77 = 1.1 time = 390
.meas tran vdout0_25ck77 FIND v(dout0_25) AT=390.025n

* CHECK dout0_26 Vdout0_26ck77 = 1.1 time = 390
.meas tran vdout0_26ck77 FIND v(dout0_26) AT=390.025n

* CHECK dout0_27 Vdout0_27ck77 = 1.1 time = 390
.meas tran vdout0_27ck77 FIND v(dout0_27) AT=390.025n

* CHECK dout0_28 Vdout0_28ck77 = 1.1 time = 390
.meas tran vdout0_28ck77 FIND v(dout0_28) AT=390.025n

* CHECK dout0_29 Vdout0_29ck77 = 1.1 time = 390
.meas tran vdout0_29ck77 FIND v(dout0_29) AT=390.025n

* CHECK dout0_30 Vdout0_30ck77 = 0 time = 390
.meas tran vdout0_30ck77 FIND v(dout0_30) AT=390.025n

* CHECK dout0_31 Vdout0_31ck77 = 1.1 time = 390
.meas tran vdout0_31ck77 FIND v(dout0_31) AT=390.025n

* CHECK dout0_0 Vdout0_0ck79 = 0 time = 400
.meas tran vdout0_0ck79 FIND v(dout0_0) AT=400.025n

* CHECK dout0_1 Vdout0_1ck79 = 0 time = 400
.meas tran vdout0_1ck79 FIND v(dout0_1) AT=400.025n

* CHECK dout0_2 Vdout0_2ck79 = 0 time = 400
.meas tran vdout0_2ck79 FIND v(dout0_2) AT=400.025n

* CHECK dout0_3 Vdout0_3ck79 = 0 time = 400
.meas tran vdout0_3ck79 FIND v(dout0_3) AT=400.025n

* CHECK dout0_4 Vdout0_4ck79 = 1.1 time = 400
.meas tran vdout0_4ck79 FIND v(dout0_4) AT=400.025n

* CHECK dout0_5 Vdout0_5ck79 = 1.1 time = 400
.meas tran vdout0_5ck79 FIND v(dout0_5) AT=400.025n

* CHECK dout0_6 Vdout0_6ck79 = 1.1 time = 400
.meas tran vdout0_6ck79 FIND v(dout0_6) AT=400.025n

* CHECK dout0_7 Vdout0_7ck79 = 1.1 time = 400
.meas tran vdout0_7ck79 FIND v(dout0_7) AT=400.025n

* CHECK dout0_8 Vdout0_8ck79 = 0 time = 400
.meas tran vdout0_8ck79 FIND v(dout0_8) AT=400.025n

* CHECK dout0_9 Vdout0_9ck79 = 0 time = 400
.meas tran vdout0_9ck79 FIND v(dout0_9) AT=400.025n

* CHECK dout0_10 Vdout0_10ck79 = 0 time = 400
.meas tran vdout0_10ck79 FIND v(dout0_10) AT=400.025n

* CHECK dout0_11 Vdout0_11ck79 = 0 time = 400
.meas tran vdout0_11ck79 FIND v(dout0_11) AT=400.025n

* CHECK dout0_12 Vdout0_12ck79 = 1.1 time = 400
.meas tran vdout0_12ck79 FIND v(dout0_12) AT=400.025n

* CHECK dout0_13 Vdout0_13ck79 = 1.1 time = 400
.meas tran vdout0_13ck79 FIND v(dout0_13) AT=400.025n

* CHECK dout0_14 Vdout0_14ck79 = 0 time = 400
.meas tran vdout0_14ck79 FIND v(dout0_14) AT=400.025n

* CHECK dout0_15 Vdout0_15ck79 = 1.1 time = 400
.meas tran vdout0_15ck79 FIND v(dout0_15) AT=400.025n

* CHECK dout0_16 Vdout0_16ck79 = 1.1 time = 400
.meas tran vdout0_16ck79 FIND v(dout0_16) AT=400.025n

* CHECK dout0_17 Vdout0_17ck79 = 1.1 time = 400
.meas tran vdout0_17ck79 FIND v(dout0_17) AT=400.025n

* CHECK dout0_18 Vdout0_18ck79 = 0 time = 400
.meas tran vdout0_18ck79 FIND v(dout0_18) AT=400.025n

* CHECK dout0_19 Vdout0_19ck79 = 0 time = 400
.meas tran vdout0_19ck79 FIND v(dout0_19) AT=400.025n

* CHECK dout0_20 Vdout0_20ck79 = 0 time = 400
.meas tran vdout0_20ck79 FIND v(dout0_20) AT=400.025n

* CHECK dout0_21 Vdout0_21ck79 = 1.1 time = 400
.meas tran vdout0_21ck79 FIND v(dout0_21) AT=400.025n

* CHECK dout0_22 Vdout0_22ck79 = 1.1 time = 400
.meas tran vdout0_22ck79 FIND v(dout0_22) AT=400.025n

* CHECK dout0_23 Vdout0_23ck79 = 0 time = 400
.meas tran vdout0_23ck79 FIND v(dout0_23) AT=400.025n

* CHECK dout0_24 Vdout0_24ck79 = 0 time = 400
.meas tran vdout0_24ck79 FIND v(dout0_24) AT=400.025n

* CHECK dout0_25 Vdout0_25ck79 = 0 time = 400
.meas tran vdout0_25ck79 FIND v(dout0_25) AT=400.025n

* CHECK dout0_26 Vdout0_26ck79 = 1.1 time = 400
.meas tran vdout0_26ck79 FIND v(dout0_26) AT=400.025n

* CHECK dout0_27 Vdout0_27ck79 = 1.1 time = 400
.meas tran vdout0_27ck79 FIND v(dout0_27) AT=400.025n

* CHECK dout0_28 Vdout0_28ck79 = 1.1 time = 400
.meas tran vdout0_28ck79 FIND v(dout0_28) AT=400.025n

* CHECK dout0_29 Vdout0_29ck79 = 1.1 time = 400
.meas tran vdout0_29ck79 FIND v(dout0_29) AT=400.025n

* CHECK dout0_30 Vdout0_30ck79 = 1.1 time = 400
.meas tran vdout0_30ck79 FIND v(dout0_30) AT=400.025n

* CHECK dout0_31 Vdout0_31ck79 = 0 time = 400
.meas tran vdout0_31ck79 FIND v(dout0_31) AT=400.025n

* CHECK dout0_0 Vdout0_0ck80 = 0 time = 405
.meas tran vdout0_0ck80 FIND v(dout0_0) AT=405.025n

* CHECK dout0_1 Vdout0_1ck80 = 1.1 time = 405
.meas tran vdout0_1ck80 FIND v(dout0_1) AT=405.025n

* CHECK dout0_2 Vdout0_2ck80 = 0 time = 405
.meas tran vdout0_2ck80 FIND v(dout0_2) AT=405.025n

* CHECK dout0_3 Vdout0_3ck80 = 1.1 time = 405
.meas tran vdout0_3ck80 FIND v(dout0_3) AT=405.025n

* CHECK dout0_4 Vdout0_4ck80 = 1.1 time = 405
.meas tran vdout0_4ck80 FIND v(dout0_4) AT=405.025n

* CHECK dout0_5 Vdout0_5ck80 = 0 time = 405
.meas tran vdout0_5ck80 FIND v(dout0_5) AT=405.025n

* CHECK dout0_6 Vdout0_6ck80 = 1.1 time = 405
.meas tran vdout0_6ck80 FIND v(dout0_6) AT=405.025n

* CHECK dout0_7 Vdout0_7ck80 = 1.1 time = 405
.meas tran vdout0_7ck80 FIND v(dout0_7) AT=405.025n

* CHECK dout0_8 Vdout0_8ck80 = 0 time = 405
.meas tran vdout0_8ck80 FIND v(dout0_8) AT=405.025n

* CHECK dout0_9 Vdout0_9ck80 = 0 time = 405
.meas tran vdout0_9ck80 FIND v(dout0_9) AT=405.025n

* CHECK dout0_10 Vdout0_10ck80 = 0 time = 405
.meas tran vdout0_10ck80 FIND v(dout0_10) AT=405.025n

* CHECK dout0_11 Vdout0_11ck80 = 0 time = 405
.meas tran vdout0_11ck80 FIND v(dout0_11) AT=405.025n

* CHECK dout0_12 Vdout0_12ck80 = 0 time = 405
.meas tran vdout0_12ck80 FIND v(dout0_12) AT=405.025n

* CHECK dout0_13 Vdout0_13ck80 = 0 time = 405
.meas tran vdout0_13ck80 FIND v(dout0_13) AT=405.025n

* CHECK dout0_14 Vdout0_14ck80 = 1.1 time = 405
.meas tran vdout0_14ck80 FIND v(dout0_14) AT=405.025n

* CHECK dout0_15 Vdout0_15ck80 = 1.1 time = 405
.meas tran vdout0_15ck80 FIND v(dout0_15) AT=405.025n

* CHECK dout0_16 Vdout0_16ck80 = 1.1 time = 405
.meas tran vdout0_16ck80 FIND v(dout0_16) AT=405.025n

* CHECK dout0_17 Vdout0_17ck80 = 0 time = 405
.meas tran vdout0_17ck80 FIND v(dout0_17) AT=405.025n

* CHECK dout0_18 Vdout0_18ck80 = 0 time = 405
.meas tran vdout0_18ck80 FIND v(dout0_18) AT=405.025n

* CHECK dout0_19 Vdout0_19ck80 = 0 time = 405
.meas tran vdout0_19ck80 FIND v(dout0_19) AT=405.025n

* CHECK dout0_20 Vdout0_20ck80 = 1.1 time = 405
.meas tran vdout0_20ck80 FIND v(dout0_20) AT=405.025n

* CHECK dout0_21 Vdout0_21ck80 = 0 time = 405
.meas tran vdout0_21ck80 FIND v(dout0_21) AT=405.025n

* CHECK dout0_22 Vdout0_22ck80 = 1.1 time = 405
.meas tran vdout0_22ck80 FIND v(dout0_22) AT=405.025n

* CHECK dout0_23 Vdout0_23ck80 = 0 time = 405
.meas tran vdout0_23ck80 FIND v(dout0_23) AT=405.025n

* CHECK dout0_24 Vdout0_24ck80 = 0 time = 405
.meas tran vdout0_24ck80 FIND v(dout0_24) AT=405.025n

* CHECK dout0_25 Vdout0_25ck80 = 0 time = 405
.meas tran vdout0_25ck80 FIND v(dout0_25) AT=405.025n

* CHECK dout0_26 Vdout0_26ck80 = 1.1 time = 405
.meas tran vdout0_26ck80 FIND v(dout0_26) AT=405.025n

* CHECK dout0_27 Vdout0_27ck80 = 1.1 time = 405
.meas tran vdout0_27ck80 FIND v(dout0_27) AT=405.025n

* CHECK dout0_28 Vdout0_28ck80 = 0 time = 405
.meas tran vdout0_28ck80 FIND v(dout0_28) AT=405.025n

* CHECK dout0_29 Vdout0_29ck80 = 1.1 time = 405
.meas tran vdout0_29ck80 FIND v(dout0_29) AT=405.025n

* CHECK dout0_30 Vdout0_30ck80 = 0 time = 405
.meas tran vdout0_30ck80 FIND v(dout0_30) AT=405.025n

* CHECK dout0_31 Vdout0_31ck80 = 0 time = 405
.meas tran vdout0_31ck80 FIND v(dout0_31) AT=405.025n

* CHECK dout0_0 Vdout0_0ck81 = 1.1 time = 410
.meas tran vdout0_0ck81 FIND v(dout0_0) AT=410.025n

* CHECK dout0_1 Vdout0_1ck81 = 1.1 time = 410
.meas tran vdout0_1ck81 FIND v(dout0_1) AT=410.025n

* CHECK dout0_2 Vdout0_2ck81 = 0 time = 410
.meas tran vdout0_2ck81 FIND v(dout0_2) AT=410.025n

* CHECK dout0_3 Vdout0_3ck81 = 0 time = 410
.meas tran vdout0_3ck81 FIND v(dout0_3) AT=410.025n

* CHECK dout0_4 Vdout0_4ck81 = 1.1 time = 410
.meas tran vdout0_4ck81 FIND v(dout0_4) AT=410.025n

* CHECK dout0_5 Vdout0_5ck81 = 1.1 time = 410
.meas tran vdout0_5ck81 FIND v(dout0_5) AT=410.025n

* CHECK dout0_6 Vdout0_6ck81 = 1.1 time = 410
.meas tran vdout0_6ck81 FIND v(dout0_6) AT=410.025n

* CHECK dout0_7 Vdout0_7ck81 = 1.1 time = 410
.meas tran vdout0_7ck81 FIND v(dout0_7) AT=410.025n

* CHECK dout0_8 Vdout0_8ck81 = 1.1 time = 410
.meas tran vdout0_8ck81 FIND v(dout0_8) AT=410.025n

* CHECK dout0_9 Vdout0_9ck81 = 1.1 time = 410
.meas tran vdout0_9ck81 FIND v(dout0_9) AT=410.025n

* CHECK dout0_10 Vdout0_10ck81 = 0 time = 410
.meas tran vdout0_10ck81 FIND v(dout0_10) AT=410.025n

* CHECK dout0_11 Vdout0_11ck81 = 1.1 time = 410
.meas tran vdout0_11ck81 FIND v(dout0_11) AT=410.025n

* CHECK dout0_12 Vdout0_12ck81 = 1.1 time = 410
.meas tran vdout0_12ck81 FIND v(dout0_12) AT=410.025n

* CHECK dout0_13 Vdout0_13ck81 = 0 time = 410
.meas tran vdout0_13ck81 FIND v(dout0_13) AT=410.025n

* CHECK dout0_14 Vdout0_14ck81 = 0 time = 410
.meas tran vdout0_14ck81 FIND v(dout0_14) AT=410.025n

* CHECK dout0_15 Vdout0_15ck81 = 0 time = 410
.meas tran vdout0_15ck81 FIND v(dout0_15) AT=410.025n

* CHECK dout0_16 Vdout0_16ck81 = 0 time = 410
.meas tran vdout0_16ck81 FIND v(dout0_16) AT=410.025n

* CHECK dout0_17 Vdout0_17ck81 = 1.1 time = 410
.meas tran vdout0_17ck81 FIND v(dout0_17) AT=410.025n

* CHECK dout0_18 Vdout0_18ck81 = 1.1 time = 410
.meas tran vdout0_18ck81 FIND v(dout0_18) AT=410.025n

* CHECK dout0_19 Vdout0_19ck81 = 1.1 time = 410
.meas tran vdout0_19ck81 FIND v(dout0_19) AT=410.025n

* CHECK dout0_20 Vdout0_20ck81 = 1.1 time = 410
.meas tran vdout0_20ck81 FIND v(dout0_20) AT=410.025n

* CHECK dout0_21 Vdout0_21ck81 = 1.1 time = 410
.meas tran vdout0_21ck81 FIND v(dout0_21) AT=410.025n

* CHECK dout0_22 Vdout0_22ck81 = 1.1 time = 410
.meas tran vdout0_22ck81 FIND v(dout0_22) AT=410.025n

* CHECK dout0_23 Vdout0_23ck81 = 1.1 time = 410
.meas tran vdout0_23ck81 FIND v(dout0_23) AT=410.025n

* CHECK dout0_24 Vdout0_24ck81 = 0 time = 410
.meas tran vdout0_24ck81 FIND v(dout0_24) AT=410.025n

* CHECK dout0_25 Vdout0_25ck81 = 1.1 time = 410
.meas tran vdout0_25ck81 FIND v(dout0_25) AT=410.025n

* CHECK dout0_26 Vdout0_26ck81 = 1.1 time = 410
.meas tran vdout0_26ck81 FIND v(dout0_26) AT=410.025n

* CHECK dout0_27 Vdout0_27ck81 = 1.1 time = 410
.meas tran vdout0_27ck81 FIND v(dout0_27) AT=410.025n

* CHECK dout0_28 Vdout0_28ck81 = 0 time = 410
.meas tran vdout0_28ck81 FIND v(dout0_28) AT=410.025n

* CHECK dout0_29 Vdout0_29ck81 = 0 time = 410
.meas tran vdout0_29ck81 FIND v(dout0_29) AT=410.025n

* CHECK dout0_30 Vdout0_30ck81 = 1.1 time = 410
.meas tran vdout0_30ck81 FIND v(dout0_30) AT=410.025n

* CHECK dout0_31 Vdout0_31ck81 = 0 time = 410
.meas tran vdout0_31ck81 FIND v(dout0_31) AT=410.025n

* CHECK dout0_0 Vdout0_0ck84 = 0 time = 425
.meas tran vdout0_0ck84 FIND v(dout0_0) AT=425.025n

* CHECK dout0_1 Vdout0_1ck84 = 1.1 time = 425
.meas tran vdout0_1ck84 FIND v(dout0_1) AT=425.025n

* CHECK dout0_2 Vdout0_2ck84 = 0 time = 425
.meas tran vdout0_2ck84 FIND v(dout0_2) AT=425.025n

* CHECK dout0_3 Vdout0_3ck84 = 1.1 time = 425
.meas tran vdout0_3ck84 FIND v(dout0_3) AT=425.025n

* CHECK dout0_4 Vdout0_4ck84 = 1.1 time = 425
.meas tran vdout0_4ck84 FIND v(dout0_4) AT=425.025n

* CHECK dout0_5 Vdout0_5ck84 = 0 time = 425
.meas tran vdout0_5ck84 FIND v(dout0_5) AT=425.025n

* CHECK dout0_6 Vdout0_6ck84 = 1.1 time = 425
.meas tran vdout0_6ck84 FIND v(dout0_6) AT=425.025n

* CHECK dout0_7 Vdout0_7ck84 = 1.1 time = 425
.meas tran vdout0_7ck84 FIND v(dout0_7) AT=425.025n

* CHECK dout0_8 Vdout0_8ck84 = 0 time = 425
.meas tran vdout0_8ck84 FIND v(dout0_8) AT=425.025n

* CHECK dout0_9 Vdout0_9ck84 = 0 time = 425
.meas tran vdout0_9ck84 FIND v(dout0_9) AT=425.025n

* CHECK dout0_10 Vdout0_10ck84 = 0 time = 425
.meas tran vdout0_10ck84 FIND v(dout0_10) AT=425.025n

* CHECK dout0_11 Vdout0_11ck84 = 0 time = 425
.meas tran vdout0_11ck84 FIND v(dout0_11) AT=425.025n

* CHECK dout0_12 Vdout0_12ck84 = 0 time = 425
.meas tran vdout0_12ck84 FIND v(dout0_12) AT=425.025n

* CHECK dout0_13 Vdout0_13ck84 = 0 time = 425
.meas tran vdout0_13ck84 FIND v(dout0_13) AT=425.025n

* CHECK dout0_14 Vdout0_14ck84 = 1.1 time = 425
.meas tran vdout0_14ck84 FIND v(dout0_14) AT=425.025n

* CHECK dout0_15 Vdout0_15ck84 = 1.1 time = 425
.meas tran vdout0_15ck84 FIND v(dout0_15) AT=425.025n

* CHECK dout0_16 Vdout0_16ck84 = 1.1 time = 425
.meas tran vdout0_16ck84 FIND v(dout0_16) AT=425.025n

* CHECK dout0_17 Vdout0_17ck84 = 0 time = 425
.meas tran vdout0_17ck84 FIND v(dout0_17) AT=425.025n

* CHECK dout0_18 Vdout0_18ck84 = 0 time = 425
.meas tran vdout0_18ck84 FIND v(dout0_18) AT=425.025n

* CHECK dout0_19 Vdout0_19ck84 = 0 time = 425
.meas tran vdout0_19ck84 FIND v(dout0_19) AT=425.025n

* CHECK dout0_20 Vdout0_20ck84 = 1.1 time = 425
.meas tran vdout0_20ck84 FIND v(dout0_20) AT=425.025n

* CHECK dout0_21 Vdout0_21ck84 = 0 time = 425
.meas tran vdout0_21ck84 FIND v(dout0_21) AT=425.025n

* CHECK dout0_22 Vdout0_22ck84 = 1.1 time = 425
.meas tran vdout0_22ck84 FIND v(dout0_22) AT=425.025n

* CHECK dout0_23 Vdout0_23ck84 = 0 time = 425
.meas tran vdout0_23ck84 FIND v(dout0_23) AT=425.025n

* CHECK dout0_24 Vdout0_24ck84 = 0 time = 425
.meas tran vdout0_24ck84 FIND v(dout0_24) AT=425.025n

* CHECK dout0_25 Vdout0_25ck84 = 0 time = 425
.meas tran vdout0_25ck84 FIND v(dout0_25) AT=425.025n

* CHECK dout0_26 Vdout0_26ck84 = 1.1 time = 425
.meas tran vdout0_26ck84 FIND v(dout0_26) AT=425.025n

* CHECK dout0_27 Vdout0_27ck84 = 1.1 time = 425
.meas tran vdout0_27ck84 FIND v(dout0_27) AT=425.025n

* CHECK dout0_28 Vdout0_28ck84 = 0 time = 425
.meas tran vdout0_28ck84 FIND v(dout0_28) AT=425.025n

* CHECK dout0_29 Vdout0_29ck84 = 1.1 time = 425
.meas tran vdout0_29ck84 FIND v(dout0_29) AT=425.025n

* CHECK dout0_30 Vdout0_30ck84 = 0 time = 425
.meas tran vdout0_30ck84 FIND v(dout0_30) AT=425.025n

* CHECK dout0_31 Vdout0_31ck84 = 0 time = 425
.meas tran vdout0_31ck84 FIND v(dout0_31) AT=425.025n

* CHECK dout0_0 Vdout0_0ck88 = 0 time = 445
.meas tran vdout0_0ck88 FIND v(dout0_0) AT=445.025n

* CHECK dout0_1 Vdout0_1ck88 = 0 time = 445
.meas tran vdout0_1ck88 FIND v(dout0_1) AT=445.025n

* CHECK dout0_2 Vdout0_2ck88 = 0 time = 445
.meas tran vdout0_2ck88 FIND v(dout0_2) AT=445.025n

* CHECK dout0_3 Vdout0_3ck88 = 0 time = 445
.meas tran vdout0_3ck88 FIND v(dout0_3) AT=445.025n

* CHECK dout0_4 Vdout0_4ck88 = 1.1 time = 445
.meas tran vdout0_4ck88 FIND v(dout0_4) AT=445.025n

* CHECK dout0_5 Vdout0_5ck88 = 1.1 time = 445
.meas tran vdout0_5ck88 FIND v(dout0_5) AT=445.025n

* CHECK dout0_6 Vdout0_6ck88 = 1.1 time = 445
.meas tran vdout0_6ck88 FIND v(dout0_6) AT=445.025n

* CHECK dout0_7 Vdout0_7ck88 = 1.1 time = 445
.meas tran vdout0_7ck88 FIND v(dout0_7) AT=445.025n

* CHECK dout0_8 Vdout0_8ck88 = 0 time = 445
.meas tran vdout0_8ck88 FIND v(dout0_8) AT=445.025n

* CHECK dout0_9 Vdout0_9ck88 = 0 time = 445
.meas tran vdout0_9ck88 FIND v(dout0_9) AT=445.025n

* CHECK dout0_10 Vdout0_10ck88 = 0 time = 445
.meas tran vdout0_10ck88 FIND v(dout0_10) AT=445.025n

* CHECK dout0_11 Vdout0_11ck88 = 0 time = 445
.meas tran vdout0_11ck88 FIND v(dout0_11) AT=445.025n

* CHECK dout0_12 Vdout0_12ck88 = 1.1 time = 445
.meas tran vdout0_12ck88 FIND v(dout0_12) AT=445.025n

* CHECK dout0_13 Vdout0_13ck88 = 1.1 time = 445
.meas tran vdout0_13ck88 FIND v(dout0_13) AT=445.025n

* CHECK dout0_14 Vdout0_14ck88 = 0 time = 445
.meas tran vdout0_14ck88 FIND v(dout0_14) AT=445.025n

* CHECK dout0_15 Vdout0_15ck88 = 1.1 time = 445
.meas tran vdout0_15ck88 FIND v(dout0_15) AT=445.025n

* CHECK dout0_16 Vdout0_16ck88 = 1.1 time = 445
.meas tran vdout0_16ck88 FIND v(dout0_16) AT=445.025n

* CHECK dout0_17 Vdout0_17ck88 = 1.1 time = 445
.meas tran vdout0_17ck88 FIND v(dout0_17) AT=445.025n

* CHECK dout0_18 Vdout0_18ck88 = 0 time = 445
.meas tran vdout0_18ck88 FIND v(dout0_18) AT=445.025n

* CHECK dout0_19 Vdout0_19ck88 = 0 time = 445
.meas tran vdout0_19ck88 FIND v(dout0_19) AT=445.025n

* CHECK dout0_20 Vdout0_20ck88 = 0 time = 445
.meas tran vdout0_20ck88 FIND v(dout0_20) AT=445.025n

* CHECK dout0_21 Vdout0_21ck88 = 1.1 time = 445
.meas tran vdout0_21ck88 FIND v(dout0_21) AT=445.025n

* CHECK dout0_22 Vdout0_22ck88 = 1.1 time = 445
.meas tran vdout0_22ck88 FIND v(dout0_22) AT=445.025n

* CHECK dout0_23 Vdout0_23ck88 = 0 time = 445
.meas tran vdout0_23ck88 FIND v(dout0_23) AT=445.025n

* CHECK dout0_24 Vdout0_24ck88 = 0 time = 445
.meas tran vdout0_24ck88 FIND v(dout0_24) AT=445.025n

* CHECK dout0_25 Vdout0_25ck88 = 0 time = 445
.meas tran vdout0_25ck88 FIND v(dout0_25) AT=445.025n

* CHECK dout0_26 Vdout0_26ck88 = 1.1 time = 445
.meas tran vdout0_26ck88 FIND v(dout0_26) AT=445.025n

* CHECK dout0_27 Vdout0_27ck88 = 1.1 time = 445
.meas tran vdout0_27ck88 FIND v(dout0_27) AT=445.025n

* CHECK dout0_28 Vdout0_28ck88 = 1.1 time = 445
.meas tran vdout0_28ck88 FIND v(dout0_28) AT=445.025n

* CHECK dout0_29 Vdout0_29ck88 = 1.1 time = 445
.meas tran vdout0_29ck88 FIND v(dout0_29) AT=445.025n

* CHECK dout0_30 Vdout0_30ck88 = 1.1 time = 445
.meas tran vdout0_30ck88 FIND v(dout0_30) AT=445.025n

* CHECK dout0_31 Vdout0_31ck88 = 0 time = 445
.meas tran vdout0_31ck88 FIND v(dout0_31) AT=445.025n

* CHECK dout0_0 Vdout0_0ck89 = 0 time = 450
.meas tran vdout0_0ck89 FIND v(dout0_0) AT=450.025n

* CHECK dout0_1 Vdout0_1ck89 = 1.1 time = 450
.meas tran vdout0_1ck89 FIND v(dout0_1) AT=450.025n

* CHECK dout0_2 Vdout0_2ck89 = 1.1 time = 450
.meas tran vdout0_2ck89 FIND v(dout0_2) AT=450.025n

* CHECK dout0_3 Vdout0_3ck89 = 1.1 time = 450
.meas tran vdout0_3ck89 FIND v(dout0_3) AT=450.025n

* CHECK dout0_4 Vdout0_4ck89 = 1.1 time = 450
.meas tran vdout0_4ck89 FIND v(dout0_4) AT=450.025n

* CHECK dout0_5 Vdout0_5ck89 = 1.1 time = 450
.meas tran vdout0_5ck89 FIND v(dout0_5) AT=450.025n

* CHECK dout0_6 Vdout0_6ck89 = 0 time = 450
.meas tran vdout0_6ck89 FIND v(dout0_6) AT=450.025n

* CHECK dout0_7 Vdout0_7ck89 = 0 time = 450
.meas tran vdout0_7ck89 FIND v(dout0_7) AT=450.025n

* CHECK dout0_8 Vdout0_8ck89 = 0 time = 450
.meas tran vdout0_8ck89 FIND v(dout0_8) AT=450.025n

* CHECK dout0_9 Vdout0_9ck89 = 1.1 time = 450
.meas tran vdout0_9ck89 FIND v(dout0_9) AT=450.025n

* CHECK dout0_10 Vdout0_10ck89 = 1.1 time = 450
.meas tran vdout0_10ck89 FIND v(dout0_10) AT=450.025n

* CHECK dout0_11 Vdout0_11ck89 = 0 time = 450
.meas tran vdout0_11ck89 FIND v(dout0_11) AT=450.025n

* CHECK dout0_12 Vdout0_12ck89 = 1.1 time = 450
.meas tran vdout0_12ck89 FIND v(dout0_12) AT=450.025n

* CHECK dout0_13 Vdout0_13ck89 = 1.1 time = 450
.meas tran vdout0_13ck89 FIND v(dout0_13) AT=450.025n

* CHECK dout0_14 Vdout0_14ck89 = 1.1 time = 450
.meas tran vdout0_14ck89 FIND v(dout0_14) AT=450.025n

* CHECK dout0_15 Vdout0_15ck89 = 1.1 time = 450
.meas tran vdout0_15ck89 FIND v(dout0_15) AT=450.025n

* CHECK dout0_16 Vdout0_16ck89 = 1.1 time = 450
.meas tran vdout0_16ck89 FIND v(dout0_16) AT=450.025n

* CHECK dout0_17 Vdout0_17ck89 = 1.1 time = 450
.meas tran vdout0_17ck89 FIND v(dout0_17) AT=450.025n

* CHECK dout0_18 Vdout0_18ck89 = 1.1 time = 450
.meas tran vdout0_18ck89 FIND v(dout0_18) AT=450.025n

* CHECK dout0_19 Vdout0_19ck89 = 1.1 time = 450
.meas tran vdout0_19ck89 FIND v(dout0_19) AT=450.025n

* CHECK dout0_20 Vdout0_20ck89 = 1.1 time = 450
.meas tran vdout0_20ck89 FIND v(dout0_20) AT=450.025n

* CHECK dout0_21 Vdout0_21ck89 = 1.1 time = 450
.meas tran vdout0_21ck89 FIND v(dout0_21) AT=450.025n

* CHECK dout0_22 Vdout0_22ck89 = 1.1 time = 450
.meas tran vdout0_22ck89 FIND v(dout0_22) AT=450.025n

* CHECK dout0_23 Vdout0_23ck89 = 0 time = 450
.meas tran vdout0_23ck89 FIND v(dout0_23) AT=450.025n

* CHECK dout0_24 Vdout0_24ck89 = 1.1 time = 450
.meas tran vdout0_24ck89 FIND v(dout0_24) AT=450.025n

* CHECK dout0_25 Vdout0_25ck89 = 1.1 time = 450
.meas tran vdout0_25ck89 FIND v(dout0_25) AT=450.025n

* CHECK dout0_26 Vdout0_26ck89 = 1.1 time = 450
.meas tran vdout0_26ck89 FIND v(dout0_26) AT=450.025n

* CHECK dout0_27 Vdout0_27ck89 = 1.1 time = 450
.meas tran vdout0_27ck89 FIND v(dout0_27) AT=450.025n

* CHECK dout0_28 Vdout0_28ck89 = 1.1 time = 450
.meas tran vdout0_28ck89 FIND v(dout0_28) AT=450.025n

* CHECK dout0_29 Vdout0_29ck89 = 1.1 time = 450
.meas tran vdout0_29ck89 FIND v(dout0_29) AT=450.025n

* CHECK dout0_30 Vdout0_30ck89 = 0 time = 450
.meas tran vdout0_30ck89 FIND v(dout0_30) AT=450.025n

* CHECK dout0_31 Vdout0_31ck89 = 0 time = 450
.meas tran vdout0_31ck89 FIND v(dout0_31) AT=450.025n

* CHECK dout0_0 Vdout0_0ck90 = 0 time = 455
.meas tran vdout0_0ck90 FIND v(dout0_0) AT=455.025n

* CHECK dout0_1 Vdout0_1ck90 = 1.1 time = 455
.meas tran vdout0_1ck90 FIND v(dout0_1) AT=455.025n

* CHECK dout0_2 Vdout0_2ck90 = 1.1 time = 455
.meas tran vdout0_2ck90 FIND v(dout0_2) AT=455.025n

* CHECK dout0_3 Vdout0_3ck90 = 1.1 time = 455
.meas tran vdout0_3ck90 FIND v(dout0_3) AT=455.025n

* CHECK dout0_4 Vdout0_4ck90 = 0 time = 455
.meas tran vdout0_4ck90 FIND v(dout0_4) AT=455.025n

* CHECK dout0_5 Vdout0_5ck90 = 1.1 time = 455
.meas tran vdout0_5ck90 FIND v(dout0_5) AT=455.025n

* CHECK dout0_6 Vdout0_6ck90 = 0 time = 455
.meas tran vdout0_6ck90 FIND v(dout0_6) AT=455.025n

* CHECK dout0_7 Vdout0_7ck90 = 0 time = 455
.meas tran vdout0_7ck90 FIND v(dout0_7) AT=455.025n

* CHECK dout0_8 Vdout0_8ck90 = 1.1 time = 455
.meas tran vdout0_8ck90 FIND v(dout0_8) AT=455.025n

* CHECK dout0_9 Vdout0_9ck90 = 1.1 time = 455
.meas tran vdout0_9ck90 FIND v(dout0_9) AT=455.025n

* CHECK dout0_10 Vdout0_10ck90 = 1.1 time = 455
.meas tran vdout0_10ck90 FIND v(dout0_10) AT=455.025n

* CHECK dout0_11 Vdout0_11ck90 = 1.1 time = 455
.meas tran vdout0_11ck90 FIND v(dout0_11) AT=455.025n

* CHECK dout0_12 Vdout0_12ck90 = 0 time = 455
.meas tran vdout0_12ck90 FIND v(dout0_12) AT=455.025n

* CHECK dout0_13 Vdout0_13ck90 = 0 time = 455
.meas tran vdout0_13ck90 FIND v(dout0_13) AT=455.025n

* CHECK dout0_14 Vdout0_14ck90 = 0 time = 455
.meas tran vdout0_14ck90 FIND v(dout0_14) AT=455.025n

* CHECK dout0_15 Vdout0_15ck90 = 0 time = 455
.meas tran vdout0_15ck90 FIND v(dout0_15) AT=455.025n

* CHECK dout0_16 Vdout0_16ck90 = 0 time = 455
.meas tran vdout0_16ck90 FIND v(dout0_16) AT=455.025n

* CHECK dout0_17 Vdout0_17ck90 = 0 time = 455
.meas tran vdout0_17ck90 FIND v(dout0_17) AT=455.025n

* CHECK dout0_18 Vdout0_18ck90 = 0 time = 455
.meas tran vdout0_18ck90 FIND v(dout0_18) AT=455.025n

* CHECK dout0_19 Vdout0_19ck90 = 1.1 time = 455
.meas tran vdout0_19ck90 FIND v(dout0_19) AT=455.025n

* CHECK dout0_20 Vdout0_20ck90 = 1.1 time = 455
.meas tran vdout0_20ck90 FIND v(dout0_20) AT=455.025n

* CHECK dout0_21 Vdout0_21ck90 = 1.1 time = 455
.meas tran vdout0_21ck90 FIND v(dout0_21) AT=455.025n

* CHECK dout0_22 Vdout0_22ck90 = 1.1 time = 455
.meas tran vdout0_22ck90 FIND v(dout0_22) AT=455.025n

* CHECK dout0_23 Vdout0_23ck90 = 1.1 time = 455
.meas tran vdout0_23ck90 FIND v(dout0_23) AT=455.025n

* CHECK dout0_24 Vdout0_24ck90 = 1.1 time = 455
.meas tran vdout0_24ck90 FIND v(dout0_24) AT=455.025n

* CHECK dout0_25 Vdout0_25ck90 = 0 time = 455
.meas tran vdout0_25ck90 FIND v(dout0_25) AT=455.025n

* CHECK dout0_26 Vdout0_26ck90 = 1.1 time = 455
.meas tran vdout0_26ck90 FIND v(dout0_26) AT=455.025n

* CHECK dout0_27 Vdout0_27ck90 = 1.1 time = 455
.meas tran vdout0_27ck90 FIND v(dout0_27) AT=455.025n

* CHECK dout0_28 Vdout0_28ck90 = 1.1 time = 455
.meas tran vdout0_28ck90 FIND v(dout0_28) AT=455.025n

* CHECK dout0_29 Vdout0_29ck90 = 0 time = 455
.meas tran vdout0_29ck90 FIND v(dout0_29) AT=455.025n

* CHECK dout0_30 Vdout0_30ck90 = 1.1 time = 455
.meas tran vdout0_30ck90 FIND v(dout0_30) AT=455.025n

* CHECK dout0_31 Vdout0_31ck90 = 1.1 time = 455
.meas tran vdout0_31ck90 FIND v(dout0_31) AT=455.025n

* CHECK dout0_0 Vdout0_0ck93 = 0 time = 470
.meas tran vdout0_0ck93 FIND v(dout0_0) AT=470.025n

* CHECK dout0_1 Vdout0_1ck93 = 1.1 time = 470
.meas tran vdout0_1ck93 FIND v(dout0_1) AT=470.025n

* CHECK dout0_2 Vdout0_2ck93 = 1.1 time = 470
.meas tran vdout0_2ck93 FIND v(dout0_2) AT=470.025n

* CHECK dout0_3 Vdout0_3ck93 = 0 time = 470
.meas tran vdout0_3ck93 FIND v(dout0_3) AT=470.025n

* CHECK dout0_4 Vdout0_4ck93 = 0 time = 470
.meas tran vdout0_4ck93 FIND v(dout0_4) AT=470.025n

* CHECK dout0_5 Vdout0_5ck93 = 1.1 time = 470
.meas tran vdout0_5ck93 FIND v(dout0_5) AT=470.025n

* CHECK dout0_6 Vdout0_6ck93 = 0 time = 470
.meas tran vdout0_6ck93 FIND v(dout0_6) AT=470.025n

* CHECK dout0_7 Vdout0_7ck93 = 0 time = 470
.meas tran vdout0_7ck93 FIND v(dout0_7) AT=470.025n

* CHECK dout0_8 Vdout0_8ck93 = 1.1 time = 470
.meas tran vdout0_8ck93 FIND v(dout0_8) AT=470.025n

* CHECK dout0_9 Vdout0_9ck93 = 0 time = 470
.meas tran vdout0_9ck93 FIND v(dout0_9) AT=470.025n

* CHECK dout0_10 Vdout0_10ck93 = 1.1 time = 470
.meas tran vdout0_10ck93 FIND v(dout0_10) AT=470.025n

* CHECK dout0_11 Vdout0_11ck93 = 1.1 time = 470
.meas tran vdout0_11ck93 FIND v(dout0_11) AT=470.025n

* CHECK dout0_12 Vdout0_12ck93 = 1.1 time = 470
.meas tran vdout0_12ck93 FIND v(dout0_12) AT=470.025n

* CHECK dout0_13 Vdout0_13ck93 = 0 time = 470
.meas tran vdout0_13ck93 FIND v(dout0_13) AT=470.025n

* CHECK dout0_14 Vdout0_14ck93 = 0 time = 470
.meas tran vdout0_14ck93 FIND v(dout0_14) AT=470.025n

* CHECK dout0_15 Vdout0_15ck93 = 1.1 time = 470
.meas tran vdout0_15ck93 FIND v(dout0_15) AT=470.025n

* CHECK dout0_16 Vdout0_16ck93 = 1.1 time = 470
.meas tran vdout0_16ck93 FIND v(dout0_16) AT=470.025n

* CHECK dout0_17 Vdout0_17ck93 = 1.1 time = 470
.meas tran vdout0_17ck93 FIND v(dout0_17) AT=470.025n

* CHECK dout0_18 Vdout0_18ck93 = 1.1 time = 470
.meas tran vdout0_18ck93 FIND v(dout0_18) AT=470.025n

* CHECK dout0_19 Vdout0_19ck93 = 1.1 time = 470
.meas tran vdout0_19ck93 FIND v(dout0_19) AT=470.025n

* CHECK dout0_20 Vdout0_20ck93 = 0 time = 470
.meas tran vdout0_20ck93 FIND v(dout0_20) AT=470.025n

* CHECK dout0_21 Vdout0_21ck93 = 1.1 time = 470
.meas tran vdout0_21ck93 FIND v(dout0_21) AT=470.025n

* CHECK dout0_22 Vdout0_22ck93 = 1.1 time = 470
.meas tran vdout0_22ck93 FIND v(dout0_22) AT=470.025n

* CHECK dout0_23 Vdout0_23ck93 = 1.1 time = 470
.meas tran vdout0_23ck93 FIND v(dout0_23) AT=470.025n

* CHECK dout0_24 Vdout0_24ck93 = 1.1 time = 470
.meas tran vdout0_24ck93 FIND v(dout0_24) AT=470.025n

* CHECK dout0_25 Vdout0_25ck93 = 1.1 time = 470
.meas tran vdout0_25ck93 FIND v(dout0_25) AT=470.025n

* CHECK dout0_26 Vdout0_26ck93 = 1.1 time = 470
.meas tran vdout0_26ck93 FIND v(dout0_26) AT=470.025n

* CHECK dout0_27 Vdout0_27ck93 = 1.1 time = 470
.meas tran vdout0_27ck93 FIND v(dout0_27) AT=470.025n

* CHECK dout0_28 Vdout0_28ck93 = 1.1 time = 470
.meas tran vdout0_28ck93 FIND v(dout0_28) AT=470.025n

* CHECK dout0_29 Vdout0_29ck93 = 1.1 time = 470
.meas tran vdout0_29ck93 FIND v(dout0_29) AT=470.025n

* CHECK dout0_30 Vdout0_30ck93 = 1.1 time = 470
.meas tran vdout0_30ck93 FIND v(dout0_30) AT=470.025n

* CHECK dout0_31 Vdout0_31ck93 = 1.1 time = 470
.meas tran vdout0_31ck93 FIND v(dout0_31) AT=470.025n

* CHECK dout0_0 Vdout0_0ck94 = 0 time = 475
.meas tran vdout0_0ck94 FIND v(dout0_0) AT=475.025n

* CHECK dout0_1 Vdout0_1ck94 = 1.1 time = 475
.meas tran vdout0_1ck94 FIND v(dout0_1) AT=475.025n

* CHECK dout0_2 Vdout0_2ck94 = 1.1 time = 475
.meas tran vdout0_2ck94 FIND v(dout0_2) AT=475.025n

* CHECK dout0_3 Vdout0_3ck94 = 1.1 time = 475
.meas tran vdout0_3ck94 FIND v(dout0_3) AT=475.025n

* CHECK dout0_4 Vdout0_4ck94 = 1.1 time = 475
.meas tran vdout0_4ck94 FIND v(dout0_4) AT=475.025n

* CHECK dout0_5 Vdout0_5ck94 = 1.1 time = 475
.meas tran vdout0_5ck94 FIND v(dout0_5) AT=475.025n

* CHECK dout0_6 Vdout0_6ck94 = 0 time = 475
.meas tran vdout0_6ck94 FIND v(dout0_6) AT=475.025n

* CHECK dout0_7 Vdout0_7ck94 = 0 time = 475
.meas tran vdout0_7ck94 FIND v(dout0_7) AT=475.025n

* CHECK dout0_8 Vdout0_8ck94 = 0 time = 475
.meas tran vdout0_8ck94 FIND v(dout0_8) AT=475.025n

* CHECK dout0_9 Vdout0_9ck94 = 1.1 time = 475
.meas tran vdout0_9ck94 FIND v(dout0_9) AT=475.025n

* CHECK dout0_10 Vdout0_10ck94 = 1.1 time = 475
.meas tran vdout0_10ck94 FIND v(dout0_10) AT=475.025n

* CHECK dout0_11 Vdout0_11ck94 = 0 time = 475
.meas tran vdout0_11ck94 FIND v(dout0_11) AT=475.025n

* CHECK dout0_12 Vdout0_12ck94 = 1.1 time = 475
.meas tran vdout0_12ck94 FIND v(dout0_12) AT=475.025n

* CHECK dout0_13 Vdout0_13ck94 = 1.1 time = 475
.meas tran vdout0_13ck94 FIND v(dout0_13) AT=475.025n

* CHECK dout0_14 Vdout0_14ck94 = 1.1 time = 475
.meas tran vdout0_14ck94 FIND v(dout0_14) AT=475.025n

* CHECK dout0_15 Vdout0_15ck94 = 1.1 time = 475
.meas tran vdout0_15ck94 FIND v(dout0_15) AT=475.025n

* CHECK dout0_16 Vdout0_16ck94 = 1.1 time = 475
.meas tran vdout0_16ck94 FIND v(dout0_16) AT=475.025n

* CHECK dout0_17 Vdout0_17ck94 = 1.1 time = 475
.meas tran vdout0_17ck94 FIND v(dout0_17) AT=475.025n

* CHECK dout0_18 Vdout0_18ck94 = 1.1 time = 475
.meas tran vdout0_18ck94 FIND v(dout0_18) AT=475.025n

* CHECK dout0_19 Vdout0_19ck94 = 1.1 time = 475
.meas tran vdout0_19ck94 FIND v(dout0_19) AT=475.025n

* CHECK dout0_20 Vdout0_20ck94 = 1.1 time = 475
.meas tran vdout0_20ck94 FIND v(dout0_20) AT=475.025n

* CHECK dout0_21 Vdout0_21ck94 = 1.1 time = 475
.meas tran vdout0_21ck94 FIND v(dout0_21) AT=475.025n

* CHECK dout0_22 Vdout0_22ck94 = 1.1 time = 475
.meas tran vdout0_22ck94 FIND v(dout0_22) AT=475.025n

* CHECK dout0_23 Vdout0_23ck94 = 0 time = 475
.meas tran vdout0_23ck94 FIND v(dout0_23) AT=475.025n

* CHECK dout0_24 Vdout0_24ck94 = 1.1 time = 475
.meas tran vdout0_24ck94 FIND v(dout0_24) AT=475.025n

* CHECK dout0_25 Vdout0_25ck94 = 1.1 time = 475
.meas tran vdout0_25ck94 FIND v(dout0_25) AT=475.025n

* CHECK dout0_26 Vdout0_26ck94 = 1.1 time = 475
.meas tran vdout0_26ck94 FIND v(dout0_26) AT=475.025n

* CHECK dout0_27 Vdout0_27ck94 = 1.1 time = 475
.meas tran vdout0_27ck94 FIND v(dout0_27) AT=475.025n

* CHECK dout0_28 Vdout0_28ck94 = 1.1 time = 475
.meas tran vdout0_28ck94 FIND v(dout0_28) AT=475.025n

* CHECK dout0_29 Vdout0_29ck94 = 1.1 time = 475
.meas tran vdout0_29ck94 FIND v(dout0_29) AT=475.025n

* CHECK dout0_30 Vdout0_30ck94 = 0 time = 475
.meas tran vdout0_30ck94 FIND v(dout0_30) AT=475.025n

* CHECK dout0_31 Vdout0_31ck94 = 0 time = 475
.meas tran vdout0_31ck94 FIND v(dout0_31) AT=475.025n

* CHECK dout0_0 Vdout0_0ck95 = 0 time = 480
.meas tran vdout0_0ck95 FIND v(dout0_0) AT=480.025n

* CHECK dout0_1 Vdout0_1ck95 = 0 time = 480
.meas tran vdout0_1ck95 FIND v(dout0_1) AT=480.025n

* CHECK dout0_2 Vdout0_2ck95 = 1.1 time = 480
.meas tran vdout0_2ck95 FIND v(dout0_2) AT=480.025n

* CHECK dout0_3 Vdout0_3ck95 = 1.1 time = 480
.meas tran vdout0_3ck95 FIND v(dout0_3) AT=480.025n

* CHECK dout0_4 Vdout0_4ck95 = 0 time = 480
.meas tran vdout0_4ck95 FIND v(dout0_4) AT=480.025n

* CHECK dout0_5 Vdout0_5ck95 = 0 time = 480
.meas tran vdout0_5ck95 FIND v(dout0_5) AT=480.025n

* CHECK dout0_6 Vdout0_6ck95 = 0 time = 480
.meas tran vdout0_6ck95 FIND v(dout0_6) AT=480.025n

* CHECK dout0_7 Vdout0_7ck95 = 1.1 time = 480
.meas tran vdout0_7ck95 FIND v(dout0_7) AT=480.025n

* CHECK dout0_8 Vdout0_8ck95 = 1.1 time = 480
.meas tran vdout0_8ck95 FIND v(dout0_8) AT=480.025n

* CHECK dout0_9 Vdout0_9ck95 = 1.1 time = 480
.meas tran vdout0_9ck95 FIND v(dout0_9) AT=480.025n

* CHECK dout0_10 Vdout0_10ck95 = 1.1 time = 480
.meas tran vdout0_10ck95 FIND v(dout0_10) AT=480.025n

* CHECK dout0_11 Vdout0_11ck95 = 0 time = 480
.meas tran vdout0_11ck95 FIND v(dout0_11) AT=480.025n

* CHECK dout0_12 Vdout0_12ck95 = 0 time = 480
.meas tran vdout0_12ck95 FIND v(dout0_12) AT=480.025n

* CHECK dout0_13 Vdout0_13ck95 = 0 time = 480
.meas tran vdout0_13ck95 FIND v(dout0_13) AT=480.025n

* CHECK dout0_14 Vdout0_14ck95 = 0 time = 480
.meas tran vdout0_14ck95 FIND v(dout0_14) AT=480.025n

* CHECK dout0_15 Vdout0_15ck95 = 1.1 time = 480
.meas tran vdout0_15ck95 FIND v(dout0_15) AT=480.025n

* CHECK dout0_16 Vdout0_16ck95 = 0 time = 480
.meas tran vdout0_16ck95 FIND v(dout0_16) AT=480.025n

* CHECK dout0_17 Vdout0_17ck95 = 0 time = 480
.meas tran vdout0_17ck95 FIND v(dout0_17) AT=480.025n

* CHECK dout0_18 Vdout0_18ck95 = 0 time = 480
.meas tran vdout0_18ck95 FIND v(dout0_18) AT=480.025n

* CHECK dout0_19 Vdout0_19ck95 = 0 time = 480
.meas tran vdout0_19ck95 FIND v(dout0_19) AT=480.025n

* CHECK dout0_20 Vdout0_20ck95 = 1.1 time = 480
.meas tran vdout0_20ck95 FIND v(dout0_20) AT=480.025n

* CHECK dout0_21 Vdout0_21ck95 = 0 time = 480
.meas tran vdout0_21ck95 FIND v(dout0_21) AT=480.025n

* CHECK dout0_22 Vdout0_22ck95 = 1.1 time = 480
.meas tran vdout0_22ck95 FIND v(dout0_22) AT=480.025n

* CHECK dout0_23 Vdout0_23ck95 = 0 time = 480
.meas tran vdout0_23ck95 FIND v(dout0_23) AT=480.025n

* CHECK dout0_24 Vdout0_24ck95 = 0 time = 480
.meas tran vdout0_24ck95 FIND v(dout0_24) AT=480.025n

* CHECK dout0_25 Vdout0_25ck95 = 0 time = 480
.meas tran vdout0_25ck95 FIND v(dout0_25) AT=480.025n

* CHECK dout0_26 Vdout0_26ck95 = 0 time = 480
.meas tran vdout0_26ck95 FIND v(dout0_26) AT=480.025n

* CHECK dout0_27 Vdout0_27ck95 = 1.1 time = 480
.meas tran vdout0_27ck95 FIND v(dout0_27) AT=480.025n

* CHECK dout0_28 Vdout0_28ck95 = 0 time = 480
.meas tran vdout0_28ck95 FIND v(dout0_28) AT=480.025n

* CHECK dout0_29 Vdout0_29ck95 = 0 time = 480
.meas tran vdout0_29ck95 FIND v(dout0_29) AT=480.025n

* CHECK dout0_30 Vdout0_30ck95 = 1.1 time = 480
.meas tran vdout0_30ck95 FIND v(dout0_30) AT=480.025n

* CHECK dout0_31 Vdout0_31ck95 = 0 time = 480
.meas tran vdout0_31ck95 FIND v(dout0_31) AT=480.025n

* CHECK dout0_0 Vdout0_0ck96 = 0 time = 485
.meas tran vdout0_0ck96 FIND v(dout0_0) AT=485.025n

* CHECK dout0_1 Vdout0_1ck96 = 1.1 time = 485
.meas tran vdout0_1ck96 FIND v(dout0_1) AT=485.025n

* CHECK dout0_2 Vdout0_2ck96 = 0 time = 485
.meas tran vdout0_2ck96 FIND v(dout0_2) AT=485.025n

* CHECK dout0_3 Vdout0_3ck96 = 1.1 time = 485
.meas tran vdout0_3ck96 FIND v(dout0_3) AT=485.025n

* CHECK dout0_4 Vdout0_4ck96 = 0 time = 485
.meas tran vdout0_4ck96 FIND v(dout0_4) AT=485.025n

* CHECK dout0_5 Vdout0_5ck96 = 0 time = 485
.meas tran vdout0_5ck96 FIND v(dout0_5) AT=485.025n

* CHECK dout0_6 Vdout0_6ck96 = 1.1 time = 485
.meas tran vdout0_6ck96 FIND v(dout0_6) AT=485.025n

* CHECK dout0_7 Vdout0_7ck96 = 0 time = 485
.meas tran vdout0_7ck96 FIND v(dout0_7) AT=485.025n

* CHECK dout0_8 Vdout0_8ck96 = 0 time = 485
.meas tran vdout0_8ck96 FIND v(dout0_8) AT=485.025n

* CHECK dout0_9 Vdout0_9ck96 = 0 time = 485
.meas tran vdout0_9ck96 FIND v(dout0_9) AT=485.025n

* CHECK dout0_10 Vdout0_10ck96 = 0 time = 485
.meas tran vdout0_10ck96 FIND v(dout0_10) AT=485.025n

* CHECK dout0_11 Vdout0_11ck96 = 0 time = 485
.meas tran vdout0_11ck96 FIND v(dout0_11) AT=485.025n

* CHECK dout0_12 Vdout0_12ck96 = 0 time = 485
.meas tran vdout0_12ck96 FIND v(dout0_12) AT=485.025n

* CHECK dout0_13 Vdout0_13ck96 = 0 time = 485
.meas tran vdout0_13ck96 FIND v(dout0_13) AT=485.025n

* CHECK dout0_14 Vdout0_14ck96 = 0 time = 485
.meas tran vdout0_14ck96 FIND v(dout0_14) AT=485.025n

* CHECK dout0_15 Vdout0_15ck96 = 0 time = 485
.meas tran vdout0_15ck96 FIND v(dout0_15) AT=485.025n

* CHECK dout0_16 Vdout0_16ck96 = 0 time = 485
.meas tran vdout0_16ck96 FIND v(dout0_16) AT=485.025n

* CHECK dout0_17 Vdout0_17ck96 = 1.1 time = 485
.meas tran vdout0_17ck96 FIND v(dout0_17) AT=485.025n

* CHECK dout0_18 Vdout0_18ck96 = 1.1 time = 485
.meas tran vdout0_18ck96 FIND v(dout0_18) AT=485.025n

* CHECK dout0_19 Vdout0_19ck96 = 1.1 time = 485
.meas tran vdout0_19ck96 FIND v(dout0_19) AT=485.025n

* CHECK dout0_20 Vdout0_20ck96 = 0 time = 485
.meas tran vdout0_20ck96 FIND v(dout0_20) AT=485.025n

* CHECK dout0_21 Vdout0_21ck96 = 0 time = 485
.meas tran vdout0_21ck96 FIND v(dout0_21) AT=485.025n

* CHECK dout0_22 Vdout0_22ck96 = 0 time = 485
.meas tran vdout0_22ck96 FIND v(dout0_22) AT=485.025n

* CHECK dout0_23 Vdout0_23ck96 = 1.1 time = 485
.meas tran vdout0_23ck96 FIND v(dout0_23) AT=485.025n

* CHECK dout0_24 Vdout0_24ck96 = 0 time = 485
.meas tran vdout0_24ck96 FIND v(dout0_24) AT=485.025n

* CHECK dout0_25 Vdout0_25ck96 = 1.1 time = 485
.meas tran vdout0_25ck96 FIND v(dout0_25) AT=485.025n

* CHECK dout0_26 Vdout0_26ck96 = 0 time = 485
.meas tran vdout0_26ck96 FIND v(dout0_26) AT=485.025n

* CHECK dout0_27 Vdout0_27ck96 = 0 time = 485
.meas tran vdout0_27ck96 FIND v(dout0_27) AT=485.025n

* CHECK dout0_28 Vdout0_28ck96 = 1.1 time = 485
.meas tran vdout0_28ck96 FIND v(dout0_28) AT=485.025n

* CHECK dout0_29 Vdout0_29ck96 = 1.1 time = 485
.meas tran vdout0_29ck96 FIND v(dout0_29) AT=485.025n

* CHECK dout0_30 Vdout0_30ck96 = 0 time = 485
.meas tran vdout0_30ck96 FIND v(dout0_30) AT=485.025n

* CHECK dout0_31 Vdout0_31ck96 = 1.1 time = 485
.meas tran vdout0_31ck96 FIND v(dout0_31) AT=485.025n

* CHECK dout0_0 Vdout0_0ck98 = 0 time = 495
.meas tran vdout0_0ck98 FIND v(dout0_0) AT=495.025n

* CHECK dout0_1 Vdout0_1ck98 = 1.1 time = 495
.meas tran vdout0_1ck98 FIND v(dout0_1) AT=495.025n

* CHECK dout0_2 Vdout0_2ck98 = 1.1 time = 495
.meas tran vdout0_2ck98 FIND v(dout0_2) AT=495.025n

* CHECK dout0_3 Vdout0_3ck98 = 1.1 time = 495
.meas tran vdout0_3ck98 FIND v(dout0_3) AT=495.025n

* CHECK dout0_4 Vdout0_4ck98 = 0 time = 495
.meas tran vdout0_4ck98 FIND v(dout0_4) AT=495.025n

* CHECK dout0_5 Vdout0_5ck98 = 1.1 time = 495
.meas tran vdout0_5ck98 FIND v(dout0_5) AT=495.025n

* CHECK dout0_6 Vdout0_6ck98 = 0 time = 495
.meas tran vdout0_6ck98 FIND v(dout0_6) AT=495.025n

* CHECK dout0_7 Vdout0_7ck98 = 0 time = 495
.meas tran vdout0_7ck98 FIND v(dout0_7) AT=495.025n

* CHECK dout0_8 Vdout0_8ck98 = 1.1 time = 495
.meas tran vdout0_8ck98 FIND v(dout0_8) AT=495.025n

* CHECK dout0_9 Vdout0_9ck98 = 1.1 time = 495
.meas tran vdout0_9ck98 FIND v(dout0_9) AT=495.025n

* CHECK dout0_10 Vdout0_10ck98 = 1.1 time = 495
.meas tran vdout0_10ck98 FIND v(dout0_10) AT=495.025n

* CHECK dout0_11 Vdout0_11ck98 = 1.1 time = 495
.meas tran vdout0_11ck98 FIND v(dout0_11) AT=495.025n

* CHECK dout0_12 Vdout0_12ck98 = 0 time = 495
.meas tran vdout0_12ck98 FIND v(dout0_12) AT=495.025n

* CHECK dout0_13 Vdout0_13ck98 = 0 time = 495
.meas tran vdout0_13ck98 FIND v(dout0_13) AT=495.025n

* CHECK dout0_14 Vdout0_14ck98 = 0 time = 495
.meas tran vdout0_14ck98 FIND v(dout0_14) AT=495.025n

* CHECK dout0_15 Vdout0_15ck98 = 0 time = 495
.meas tran vdout0_15ck98 FIND v(dout0_15) AT=495.025n

* CHECK dout0_16 Vdout0_16ck98 = 0 time = 495
.meas tran vdout0_16ck98 FIND v(dout0_16) AT=495.025n

* CHECK dout0_17 Vdout0_17ck98 = 0 time = 495
.meas tran vdout0_17ck98 FIND v(dout0_17) AT=495.025n

* CHECK dout0_18 Vdout0_18ck98 = 0 time = 495
.meas tran vdout0_18ck98 FIND v(dout0_18) AT=495.025n

* CHECK dout0_19 Vdout0_19ck98 = 1.1 time = 495
.meas tran vdout0_19ck98 FIND v(dout0_19) AT=495.025n

* CHECK dout0_20 Vdout0_20ck98 = 1.1 time = 495
.meas tran vdout0_20ck98 FIND v(dout0_20) AT=495.025n

* CHECK dout0_21 Vdout0_21ck98 = 1.1 time = 495
.meas tran vdout0_21ck98 FIND v(dout0_21) AT=495.025n

* CHECK dout0_22 Vdout0_22ck98 = 1.1 time = 495
.meas tran vdout0_22ck98 FIND v(dout0_22) AT=495.025n

* CHECK dout0_23 Vdout0_23ck98 = 1.1 time = 495
.meas tran vdout0_23ck98 FIND v(dout0_23) AT=495.025n

* CHECK dout0_24 Vdout0_24ck98 = 1.1 time = 495
.meas tran vdout0_24ck98 FIND v(dout0_24) AT=495.025n

* CHECK dout0_25 Vdout0_25ck98 = 0 time = 495
.meas tran vdout0_25ck98 FIND v(dout0_25) AT=495.025n

* CHECK dout0_26 Vdout0_26ck98 = 1.1 time = 495
.meas tran vdout0_26ck98 FIND v(dout0_26) AT=495.025n

* CHECK dout0_27 Vdout0_27ck98 = 1.1 time = 495
.meas tran vdout0_27ck98 FIND v(dout0_27) AT=495.025n

* CHECK dout0_28 Vdout0_28ck98 = 1.1 time = 495
.meas tran vdout0_28ck98 FIND v(dout0_28) AT=495.025n

* CHECK dout0_29 Vdout0_29ck98 = 0 time = 495
.meas tran vdout0_29ck98 FIND v(dout0_29) AT=495.025n

* CHECK dout0_30 Vdout0_30ck98 = 1.1 time = 495
.meas tran vdout0_30ck98 FIND v(dout0_30) AT=495.025n

* CHECK dout0_31 Vdout0_31ck98 = 1.1 time = 495
.meas tran vdout0_31ck98 FIND v(dout0_31) AT=495.025n

* CHECK dout0_0 Vdout0_0ck99 = 0 time = 500
.meas tran vdout0_0ck99 FIND v(dout0_0) AT=500.025n

* CHECK dout0_1 Vdout0_1ck99 = 1.1 time = 500
.meas tran vdout0_1ck99 FIND v(dout0_1) AT=500.025n

* CHECK dout0_2 Vdout0_2ck99 = 0 time = 500
.meas tran vdout0_2ck99 FIND v(dout0_2) AT=500.025n

* CHECK dout0_3 Vdout0_3ck99 = 1.1 time = 500
.meas tran vdout0_3ck99 FIND v(dout0_3) AT=500.025n

* CHECK dout0_4 Vdout0_4ck99 = 1.1 time = 500
.meas tran vdout0_4ck99 FIND v(dout0_4) AT=500.025n

* CHECK dout0_5 Vdout0_5ck99 = 0 time = 500
.meas tran vdout0_5ck99 FIND v(dout0_5) AT=500.025n

* CHECK dout0_6 Vdout0_6ck99 = 1.1 time = 500
.meas tran vdout0_6ck99 FIND v(dout0_6) AT=500.025n

* CHECK dout0_7 Vdout0_7ck99 = 1.1 time = 500
.meas tran vdout0_7ck99 FIND v(dout0_7) AT=500.025n

* CHECK dout0_8 Vdout0_8ck99 = 0 time = 500
.meas tran vdout0_8ck99 FIND v(dout0_8) AT=500.025n

* CHECK dout0_9 Vdout0_9ck99 = 0 time = 500
.meas tran vdout0_9ck99 FIND v(dout0_9) AT=500.025n

* CHECK dout0_10 Vdout0_10ck99 = 0 time = 500
.meas tran vdout0_10ck99 FIND v(dout0_10) AT=500.025n

* CHECK dout0_11 Vdout0_11ck99 = 0 time = 500
.meas tran vdout0_11ck99 FIND v(dout0_11) AT=500.025n

* CHECK dout0_12 Vdout0_12ck99 = 0 time = 500
.meas tran vdout0_12ck99 FIND v(dout0_12) AT=500.025n

* CHECK dout0_13 Vdout0_13ck99 = 0 time = 500
.meas tran vdout0_13ck99 FIND v(dout0_13) AT=500.025n

* CHECK dout0_14 Vdout0_14ck99 = 1.1 time = 500
.meas tran vdout0_14ck99 FIND v(dout0_14) AT=500.025n

* CHECK dout0_15 Vdout0_15ck99 = 1.1 time = 500
.meas tran vdout0_15ck99 FIND v(dout0_15) AT=500.025n

* CHECK dout0_16 Vdout0_16ck99 = 1.1 time = 500
.meas tran vdout0_16ck99 FIND v(dout0_16) AT=500.025n

* CHECK dout0_17 Vdout0_17ck99 = 0 time = 500
.meas tran vdout0_17ck99 FIND v(dout0_17) AT=500.025n

* CHECK dout0_18 Vdout0_18ck99 = 0 time = 500
.meas tran vdout0_18ck99 FIND v(dout0_18) AT=500.025n

* CHECK dout0_19 Vdout0_19ck99 = 0 time = 500
.meas tran vdout0_19ck99 FIND v(dout0_19) AT=500.025n

* CHECK dout0_20 Vdout0_20ck99 = 1.1 time = 500
.meas tran vdout0_20ck99 FIND v(dout0_20) AT=500.025n

* CHECK dout0_21 Vdout0_21ck99 = 0 time = 500
.meas tran vdout0_21ck99 FIND v(dout0_21) AT=500.025n

* CHECK dout0_22 Vdout0_22ck99 = 1.1 time = 500
.meas tran vdout0_22ck99 FIND v(dout0_22) AT=500.025n

* CHECK dout0_23 Vdout0_23ck99 = 0 time = 500
.meas tran vdout0_23ck99 FIND v(dout0_23) AT=500.025n

* CHECK dout0_24 Vdout0_24ck99 = 0 time = 500
.meas tran vdout0_24ck99 FIND v(dout0_24) AT=500.025n

* CHECK dout0_25 Vdout0_25ck99 = 0 time = 500
.meas tran vdout0_25ck99 FIND v(dout0_25) AT=500.025n

* CHECK dout0_26 Vdout0_26ck99 = 1.1 time = 500
.meas tran vdout0_26ck99 FIND v(dout0_26) AT=500.025n

* CHECK dout0_27 Vdout0_27ck99 = 1.1 time = 500
.meas tran vdout0_27ck99 FIND v(dout0_27) AT=500.025n

* CHECK dout0_28 Vdout0_28ck99 = 0 time = 500
.meas tran vdout0_28ck99 FIND v(dout0_28) AT=500.025n

* CHECK dout0_29 Vdout0_29ck99 = 1.1 time = 500
.meas tran vdout0_29ck99 FIND v(dout0_29) AT=500.025n

* CHECK dout0_30 Vdout0_30ck99 = 0 time = 500
.meas tran vdout0_30ck99 FIND v(dout0_30) AT=500.025n

* CHECK dout0_31 Vdout0_31ck99 = 0 time = 500
.meas tran vdout0_31ck99 FIND v(dout0_31) AT=500.025n

* CHECK dout0_0 Vdout0_0ck100 = 0 time = 505
.meas tran vdout0_0ck100 FIND v(dout0_0) AT=505.025n

* CHECK dout0_1 Vdout0_1ck100 = 1.1 time = 505
.meas tran vdout0_1ck100 FIND v(dout0_1) AT=505.025n

* CHECK dout0_2 Vdout0_2ck100 = 1.1 time = 505
.meas tran vdout0_2ck100 FIND v(dout0_2) AT=505.025n

* CHECK dout0_3 Vdout0_3ck100 = 1.1 time = 505
.meas tran vdout0_3ck100 FIND v(dout0_3) AT=505.025n

* CHECK dout0_4 Vdout0_4ck100 = 1.1 time = 505
.meas tran vdout0_4ck100 FIND v(dout0_4) AT=505.025n

* CHECK dout0_5 Vdout0_5ck100 = 1.1 time = 505
.meas tran vdout0_5ck100 FIND v(dout0_5) AT=505.025n

* CHECK dout0_6 Vdout0_6ck100 = 0 time = 505
.meas tran vdout0_6ck100 FIND v(dout0_6) AT=505.025n

* CHECK dout0_7 Vdout0_7ck100 = 0 time = 505
.meas tran vdout0_7ck100 FIND v(dout0_7) AT=505.025n

* CHECK dout0_8 Vdout0_8ck100 = 0 time = 505
.meas tran vdout0_8ck100 FIND v(dout0_8) AT=505.025n

* CHECK dout0_9 Vdout0_9ck100 = 1.1 time = 505
.meas tran vdout0_9ck100 FIND v(dout0_9) AT=505.025n

* CHECK dout0_10 Vdout0_10ck100 = 1.1 time = 505
.meas tran vdout0_10ck100 FIND v(dout0_10) AT=505.025n

* CHECK dout0_11 Vdout0_11ck100 = 0 time = 505
.meas tran vdout0_11ck100 FIND v(dout0_11) AT=505.025n

* CHECK dout0_12 Vdout0_12ck100 = 1.1 time = 505
.meas tran vdout0_12ck100 FIND v(dout0_12) AT=505.025n

* CHECK dout0_13 Vdout0_13ck100 = 1.1 time = 505
.meas tran vdout0_13ck100 FIND v(dout0_13) AT=505.025n

* CHECK dout0_14 Vdout0_14ck100 = 1.1 time = 505
.meas tran vdout0_14ck100 FIND v(dout0_14) AT=505.025n

* CHECK dout0_15 Vdout0_15ck100 = 1.1 time = 505
.meas tran vdout0_15ck100 FIND v(dout0_15) AT=505.025n

* CHECK dout0_16 Vdout0_16ck100 = 1.1 time = 505
.meas tran vdout0_16ck100 FIND v(dout0_16) AT=505.025n

* CHECK dout0_17 Vdout0_17ck100 = 1.1 time = 505
.meas tran vdout0_17ck100 FIND v(dout0_17) AT=505.025n

* CHECK dout0_18 Vdout0_18ck100 = 1.1 time = 505
.meas tran vdout0_18ck100 FIND v(dout0_18) AT=505.025n

* CHECK dout0_19 Vdout0_19ck100 = 1.1 time = 505
.meas tran vdout0_19ck100 FIND v(dout0_19) AT=505.025n

* CHECK dout0_20 Vdout0_20ck100 = 1.1 time = 505
.meas tran vdout0_20ck100 FIND v(dout0_20) AT=505.025n

* CHECK dout0_21 Vdout0_21ck100 = 1.1 time = 505
.meas tran vdout0_21ck100 FIND v(dout0_21) AT=505.025n

* CHECK dout0_22 Vdout0_22ck100 = 1.1 time = 505
.meas tran vdout0_22ck100 FIND v(dout0_22) AT=505.025n

* CHECK dout0_23 Vdout0_23ck100 = 0 time = 505
.meas tran vdout0_23ck100 FIND v(dout0_23) AT=505.025n

* CHECK dout0_24 Vdout0_24ck100 = 1.1 time = 505
.meas tran vdout0_24ck100 FIND v(dout0_24) AT=505.025n

* CHECK dout0_25 Vdout0_25ck100 = 1.1 time = 505
.meas tran vdout0_25ck100 FIND v(dout0_25) AT=505.025n

* CHECK dout0_26 Vdout0_26ck100 = 1.1 time = 505
.meas tran vdout0_26ck100 FIND v(dout0_26) AT=505.025n

* CHECK dout0_27 Vdout0_27ck100 = 1.1 time = 505
.meas tran vdout0_27ck100 FIND v(dout0_27) AT=505.025n

* CHECK dout0_28 Vdout0_28ck100 = 1.1 time = 505
.meas tran vdout0_28ck100 FIND v(dout0_28) AT=505.025n

* CHECK dout0_29 Vdout0_29ck100 = 1.1 time = 505
.meas tran vdout0_29ck100 FIND v(dout0_29) AT=505.025n

* CHECK dout0_30 Vdout0_30ck100 = 0 time = 505
.meas tran vdout0_30ck100 FIND v(dout0_30) AT=505.025n

* CHECK dout0_31 Vdout0_31ck100 = 0 time = 505
.meas tran vdout0_31ck100 FIND v(dout0_31) AT=505.025n

* CHECK dout0_0 Vdout0_0ck102 = 0 time = 515
.meas tran vdout0_0ck102 FIND v(dout0_0) AT=515.025n

* CHECK dout0_1 Vdout0_1ck102 = 1.1 time = 515
.meas tran vdout0_1ck102 FIND v(dout0_1) AT=515.025n

* CHECK dout0_2 Vdout0_2ck102 = 1.1 time = 515
.meas tran vdout0_2ck102 FIND v(dout0_2) AT=515.025n

* CHECK dout0_3 Vdout0_3ck102 = 1.1 time = 515
.meas tran vdout0_3ck102 FIND v(dout0_3) AT=515.025n

* CHECK dout0_4 Vdout0_4ck102 = 1.1 time = 515
.meas tran vdout0_4ck102 FIND v(dout0_4) AT=515.025n

* CHECK dout0_5 Vdout0_5ck102 = 1.1 time = 515
.meas tran vdout0_5ck102 FIND v(dout0_5) AT=515.025n

* CHECK dout0_6 Vdout0_6ck102 = 0 time = 515
.meas tran vdout0_6ck102 FIND v(dout0_6) AT=515.025n

* CHECK dout0_7 Vdout0_7ck102 = 0 time = 515
.meas tran vdout0_7ck102 FIND v(dout0_7) AT=515.025n

* CHECK dout0_8 Vdout0_8ck102 = 0 time = 515
.meas tran vdout0_8ck102 FIND v(dout0_8) AT=515.025n

* CHECK dout0_9 Vdout0_9ck102 = 1.1 time = 515
.meas tran vdout0_9ck102 FIND v(dout0_9) AT=515.025n

* CHECK dout0_10 Vdout0_10ck102 = 1.1 time = 515
.meas tran vdout0_10ck102 FIND v(dout0_10) AT=515.025n

* CHECK dout0_11 Vdout0_11ck102 = 0 time = 515
.meas tran vdout0_11ck102 FIND v(dout0_11) AT=515.025n

* CHECK dout0_12 Vdout0_12ck102 = 1.1 time = 515
.meas tran vdout0_12ck102 FIND v(dout0_12) AT=515.025n

* CHECK dout0_13 Vdout0_13ck102 = 1.1 time = 515
.meas tran vdout0_13ck102 FIND v(dout0_13) AT=515.025n

* CHECK dout0_14 Vdout0_14ck102 = 1.1 time = 515
.meas tran vdout0_14ck102 FIND v(dout0_14) AT=515.025n

* CHECK dout0_15 Vdout0_15ck102 = 1.1 time = 515
.meas tran vdout0_15ck102 FIND v(dout0_15) AT=515.025n

* CHECK dout0_16 Vdout0_16ck102 = 1.1 time = 515
.meas tran vdout0_16ck102 FIND v(dout0_16) AT=515.025n

* CHECK dout0_17 Vdout0_17ck102 = 1.1 time = 515
.meas tran vdout0_17ck102 FIND v(dout0_17) AT=515.025n

* CHECK dout0_18 Vdout0_18ck102 = 1.1 time = 515
.meas tran vdout0_18ck102 FIND v(dout0_18) AT=515.025n

* CHECK dout0_19 Vdout0_19ck102 = 1.1 time = 515
.meas tran vdout0_19ck102 FIND v(dout0_19) AT=515.025n

* CHECK dout0_20 Vdout0_20ck102 = 1.1 time = 515
.meas tran vdout0_20ck102 FIND v(dout0_20) AT=515.025n

* CHECK dout0_21 Vdout0_21ck102 = 1.1 time = 515
.meas tran vdout0_21ck102 FIND v(dout0_21) AT=515.025n

* CHECK dout0_22 Vdout0_22ck102 = 1.1 time = 515
.meas tran vdout0_22ck102 FIND v(dout0_22) AT=515.025n

* CHECK dout0_23 Vdout0_23ck102 = 0 time = 515
.meas tran vdout0_23ck102 FIND v(dout0_23) AT=515.025n

* CHECK dout0_24 Vdout0_24ck102 = 1.1 time = 515
.meas tran vdout0_24ck102 FIND v(dout0_24) AT=515.025n

* CHECK dout0_25 Vdout0_25ck102 = 1.1 time = 515
.meas tran vdout0_25ck102 FIND v(dout0_25) AT=515.025n

* CHECK dout0_26 Vdout0_26ck102 = 1.1 time = 515
.meas tran vdout0_26ck102 FIND v(dout0_26) AT=515.025n

* CHECK dout0_27 Vdout0_27ck102 = 1.1 time = 515
.meas tran vdout0_27ck102 FIND v(dout0_27) AT=515.025n

* CHECK dout0_28 Vdout0_28ck102 = 1.1 time = 515
.meas tran vdout0_28ck102 FIND v(dout0_28) AT=515.025n

* CHECK dout0_29 Vdout0_29ck102 = 1.1 time = 515
.meas tran vdout0_29ck102 FIND v(dout0_29) AT=515.025n

* CHECK dout0_30 Vdout0_30ck102 = 0 time = 515
.meas tran vdout0_30ck102 FIND v(dout0_30) AT=515.025n

* CHECK dout0_31 Vdout0_31ck102 = 0 time = 515
.meas tran vdout0_31ck102 FIND v(dout0_31) AT=515.025n

* CHECK dout0_0 Vdout0_0ck103 = 0 time = 520
.meas tran vdout0_0ck103 FIND v(dout0_0) AT=520.025n

* CHECK dout0_1 Vdout0_1ck103 = 1.1 time = 520
.meas tran vdout0_1ck103 FIND v(dout0_1) AT=520.025n

* CHECK dout0_2 Vdout0_2ck103 = 1.1 time = 520
.meas tran vdout0_2ck103 FIND v(dout0_2) AT=520.025n

* CHECK dout0_3 Vdout0_3ck103 = 1.1 time = 520
.meas tran vdout0_3ck103 FIND v(dout0_3) AT=520.025n

* CHECK dout0_4 Vdout0_4ck103 = 1.1 time = 520
.meas tran vdout0_4ck103 FIND v(dout0_4) AT=520.025n

* CHECK dout0_5 Vdout0_5ck103 = 1.1 time = 520
.meas tran vdout0_5ck103 FIND v(dout0_5) AT=520.025n

* CHECK dout0_6 Vdout0_6ck103 = 0 time = 520
.meas tran vdout0_6ck103 FIND v(dout0_6) AT=520.025n

* CHECK dout0_7 Vdout0_7ck103 = 0 time = 520
.meas tran vdout0_7ck103 FIND v(dout0_7) AT=520.025n

* CHECK dout0_8 Vdout0_8ck103 = 0 time = 520
.meas tran vdout0_8ck103 FIND v(dout0_8) AT=520.025n

* CHECK dout0_9 Vdout0_9ck103 = 1.1 time = 520
.meas tran vdout0_9ck103 FIND v(dout0_9) AT=520.025n

* CHECK dout0_10 Vdout0_10ck103 = 1.1 time = 520
.meas tran vdout0_10ck103 FIND v(dout0_10) AT=520.025n

* CHECK dout0_11 Vdout0_11ck103 = 0 time = 520
.meas tran vdout0_11ck103 FIND v(dout0_11) AT=520.025n

* CHECK dout0_12 Vdout0_12ck103 = 1.1 time = 520
.meas tran vdout0_12ck103 FIND v(dout0_12) AT=520.025n

* CHECK dout0_13 Vdout0_13ck103 = 1.1 time = 520
.meas tran vdout0_13ck103 FIND v(dout0_13) AT=520.025n

* CHECK dout0_14 Vdout0_14ck103 = 1.1 time = 520
.meas tran vdout0_14ck103 FIND v(dout0_14) AT=520.025n

* CHECK dout0_15 Vdout0_15ck103 = 1.1 time = 520
.meas tran vdout0_15ck103 FIND v(dout0_15) AT=520.025n

* CHECK dout0_16 Vdout0_16ck103 = 1.1 time = 520
.meas tran vdout0_16ck103 FIND v(dout0_16) AT=520.025n

* CHECK dout0_17 Vdout0_17ck103 = 1.1 time = 520
.meas tran vdout0_17ck103 FIND v(dout0_17) AT=520.025n

* CHECK dout0_18 Vdout0_18ck103 = 1.1 time = 520
.meas tran vdout0_18ck103 FIND v(dout0_18) AT=520.025n

* CHECK dout0_19 Vdout0_19ck103 = 1.1 time = 520
.meas tran vdout0_19ck103 FIND v(dout0_19) AT=520.025n

* CHECK dout0_20 Vdout0_20ck103 = 1.1 time = 520
.meas tran vdout0_20ck103 FIND v(dout0_20) AT=520.025n

* CHECK dout0_21 Vdout0_21ck103 = 1.1 time = 520
.meas tran vdout0_21ck103 FIND v(dout0_21) AT=520.025n

* CHECK dout0_22 Vdout0_22ck103 = 1.1 time = 520
.meas tran vdout0_22ck103 FIND v(dout0_22) AT=520.025n

* CHECK dout0_23 Vdout0_23ck103 = 0 time = 520
.meas tran vdout0_23ck103 FIND v(dout0_23) AT=520.025n

* CHECK dout0_24 Vdout0_24ck103 = 1.1 time = 520
.meas tran vdout0_24ck103 FIND v(dout0_24) AT=520.025n

* CHECK dout0_25 Vdout0_25ck103 = 1.1 time = 520
.meas tran vdout0_25ck103 FIND v(dout0_25) AT=520.025n

* CHECK dout0_26 Vdout0_26ck103 = 1.1 time = 520
.meas tran vdout0_26ck103 FIND v(dout0_26) AT=520.025n

* CHECK dout0_27 Vdout0_27ck103 = 1.1 time = 520
.meas tran vdout0_27ck103 FIND v(dout0_27) AT=520.025n

* CHECK dout0_28 Vdout0_28ck103 = 1.1 time = 520
.meas tran vdout0_28ck103 FIND v(dout0_28) AT=520.025n

* CHECK dout0_29 Vdout0_29ck103 = 1.1 time = 520
.meas tran vdout0_29ck103 FIND v(dout0_29) AT=520.025n

* CHECK dout0_30 Vdout0_30ck103 = 0 time = 520
.meas tran vdout0_30ck103 FIND v(dout0_30) AT=520.025n

* CHECK dout0_31 Vdout0_31ck103 = 0 time = 520
.meas tran vdout0_31ck103 FIND v(dout0_31) AT=520.025n

* CHECK dout0_0 Vdout0_0ck105 = 1.1 time = 530
.meas tran vdout0_0ck105 FIND v(dout0_0) AT=530.025n

* CHECK dout0_1 Vdout0_1ck105 = 0 time = 530
.meas tran vdout0_1ck105 FIND v(dout0_1) AT=530.025n

* CHECK dout0_2 Vdout0_2ck105 = 1.1 time = 530
.meas tran vdout0_2ck105 FIND v(dout0_2) AT=530.025n

* CHECK dout0_3 Vdout0_3ck105 = 1.1 time = 530
.meas tran vdout0_3ck105 FIND v(dout0_3) AT=530.025n

* CHECK dout0_4 Vdout0_4ck105 = 0 time = 530
.meas tran vdout0_4ck105 FIND v(dout0_4) AT=530.025n

* CHECK dout0_5 Vdout0_5ck105 = 1.1 time = 530
.meas tran vdout0_5ck105 FIND v(dout0_5) AT=530.025n

* CHECK dout0_6 Vdout0_6ck105 = 1.1 time = 530
.meas tran vdout0_6ck105 FIND v(dout0_6) AT=530.025n

* CHECK dout0_7 Vdout0_7ck105 = 0 time = 530
.meas tran vdout0_7ck105 FIND v(dout0_7) AT=530.025n

* CHECK dout0_8 Vdout0_8ck105 = 1.1 time = 530
.meas tran vdout0_8ck105 FIND v(dout0_8) AT=530.025n

* CHECK dout0_9 Vdout0_9ck105 = 0 time = 530
.meas tran vdout0_9ck105 FIND v(dout0_9) AT=530.025n

* CHECK dout0_10 Vdout0_10ck105 = 1.1 time = 530
.meas tran vdout0_10ck105 FIND v(dout0_10) AT=530.025n

* CHECK dout0_11 Vdout0_11ck105 = 0 time = 530
.meas tran vdout0_11ck105 FIND v(dout0_11) AT=530.025n

* CHECK dout0_12 Vdout0_12ck105 = 1.1 time = 530
.meas tran vdout0_12ck105 FIND v(dout0_12) AT=530.025n

* CHECK dout0_13 Vdout0_13ck105 = 1.1 time = 530
.meas tran vdout0_13ck105 FIND v(dout0_13) AT=530.025n

* CHECK dout0_14 Vdout0_14ck105 = 1.1 time = 530
.meas tran vdout0_14ck105 FIND v(dout0_14) AT=530.025n

* CHECK dout0_15 Vdout0_15ck105 = 0 time = 530
.meas tran vdout0_15ck105 FIND v(dout0_15) AT=530.025n

* CHECK dout0_16 Vdout0_16ck105 = 0 time = 530
.meas tran vdout0_16ck105 FIND v(dout0_16) AT=530.025n

* CHECK dout0_17 Vdout0_17ck105 = 1.1 time = 530
.meas tran vdout0_17ck105 FIND v(dout0_17) AT=530.025n

* CHECK dout0_18 Vdout0_18ck105 = 0 time = 530
.meas tran vdout0_18ck105 FIND v(dout0_18) AT=530.025n

* CHECK dout0_19 Vdout0_19ck105 = 1.1 time = 530
.meas tran vdout0_19ck105 FIND v(dout0_19) AT=530.025n

* CHECK dout0_20 Vdout0_20ck105 = 0 time = 530
.meas tran vdout0_20ck105 FIND v(dout0_20) AT=530.025n

* CHECK dout0_21 Vdout0_21ck105 = 0 time = 530
.meas tran vdout0_21ck105 FIND v(dout0_21) AT=530.025n

* CHECK dout0_22 Vdout0_22ck105 = 0 time = 530
.meas tran vdout0_22ck105 FIND v(dout0_22) AT=530.025n

* CHECK dout0_23 Vdout0_23ck105 = 1.1 time = 530
.meas tran vdout0_23ck105 FIND v(dout0_23) AT=530.025n

* CHECK dout0_24 Vdout0_24ck105 = 1.1 time = 530
.meas tran vdout0_24ck105 FIND v(dout0_24) AT=530.025n

* CHECK dout0_25 Vdout0_25ck105 = 0 time = 530
.meas tran vdout0_25ck105 FIND v(dout0_25) AT=530.025n

* CHECK dout0_26 Vdout0_26ck105 = 1.1 time = 530
.meas tran vdout0_26ck105 FIND v(dout0_26) AT=530.025n

* CHECK dout0_27 Vdout0_27ck105 = 0 time = 530
.meas tran vdout0_27ck105 FIND v(dout0_27) AT=530.025n

* CHECK dout0_28 Vdout0_28ck105 = 1.1 time = 530
.meas tran vdout0_28ck105 FIND v(dout0_28) AT=530.025n

* CHECK dout0_29 Vdout0_29ck105 = 0 time = 530
.meas tran vdout0_29ck105 FIND v(dout0_29) AT=530.025n

* CHECK dout0_30 Vdout0_30ck105 = 1.1 time = 530
.meas tran vdout0_30ck105 FIND v(dout0_30) AT=530.025n

* CHECK dout0_31 Vdout0_31ck105 = 0 time = 530
.meas tran vdout0_31ck105 FIND v(dout0_31) AT=530.025n

* CHECK dout0_0 Vdout0_0ck106 = 0 time = 535
.meas tran vdout0_0ck106 FIND v(dout0_0) AT=535.025n

* CHECK dout0_1 Vdout0_1ck106 = 1.1 time = 535
.meas tran vdout0_1ck106 FIND v(dout0_1) AT=535.025n

* CHECK dout0_2 Vdout0_2ck106 = 1.1 time = 535
.meas tran vdout0_2ck106 FIND v(dout0_2) AT=535.025n

* CHECK dout0_3 Vdout0_3ck106 = 1.1 time = 535
.meas tran vdout0_3ck106 FIND v(dout0_3) AT=535.025n

* CHECK dout0_4 Vdout0_4ck106 = 1.1 time = 535
.meas tran vdout0_4ck106 FIND v(dout0_4) AT=535.025n

* CHECK dout0_5 Vdout0_5ck106 = 1.1 time = 535
.meas tran vdout0_5ck106 FIND v(dout0_5) AT=535.025n

* CHECK dout0_6 Vdout0_6ck106 = 0 time = 535
.meas tran vdout0_6ck106 FIND v(dout0_6) AT=535.025n

* CHECK dout0_7 Vdout0_7ck106 = 0 time = 535
.meas tran vdout0_7ck106 FIND v(dout0_7) AT=535.025n

* CHECK dout0_8 Vdout0_8ck106 = 0 time = 535
.meas tran vdout0_8ck106 FIND v(dout0_8) AT=535.025n

* CHECK dout0_9 Vdout0_9ck106 = 1.1 time = 535
.meas tran vdout0_9ck106 FIND v(dout0_9) AT=535.025n

* CHECK dout0_10 Vdout0_10ck106 = 1.1 time = 535
.meas tran vdout0_10ck106 FIND v(dout0_10) AT=535.025n

* CHECK dout0_11 Vdout0_11ck106 = 0 time = 535
.meas tran vdout0_11ck106 FIND v(dout0_11) AT=535.025n

* CHECK dout0_12 Vdout0_12ck106 = 1.1 time = 535
.meas tran vdout0_12ck106 FIND v(dout0_12) AT=535.025n

* CHECK dout0_13 Vdout0_13ck106 = 1.1 time = 535
.meas tran vdout0_13ck106 FIND v(dout0_13) AT=535.025n

* CHECK dout0_14 Vdout0_14ck106 = 1.1 time = 535
.meas tran vdout0_14ck106 FIND v(dout0_14) AT=535.025n

* CHECK dout0_15 Vdout0_15ck106 = 1.1 time = 535
.meas tran vdout0_15ck106 FIND v(dout0_15) AT=535.025n

* CHECK dout0_16 Vdout0_16ck106 = 1.1 time = 535
.meas tran vdout0_16ck106 FIND v(dout0_16) AT=535.025n

* CHECK dout0_17 Vdout0_17ck106 = 1.1 time = 535
.meas tran vdout0_17ck106 FIND v(dout0_17) AT=535.025n

* CHECK dout0_18 Vdout0_18ck106 = 1.1 time = 535
.meas tran vdout0_18ck106 FIND v(dout0_18) AT=535.025n

* CHECK dout0_19 Vdout0_19ck106 = 1.1 time = 535
.meas tran vdout0_19ck106 FIND v(dout0_19) AT=535.025n

* CHECK dout0_20 Vdout0_20ck106 = 1.1 time = 535
.meas tran vdout0_20ck106 FIND v(dout0_20) AT=535.025n

* CHECK dout0_21 Vdout0_21ck106 = 1.1 time = 535
.meas tran vdout0_21ck106 FIND v(dout0_21) AT=535.025n

* CHECK dout0_22 Vdout0_22ck106 = 1.1 time = 535
.meas tran vdout0_22ck106 FIND v(dout0_22) AT=535.025n

* CHECK dout0_23 Vdout0_23ck106 = 0 time = 535
.meas tran vdout0_23ck106 FIND v(dout0_23) AT=535.025n

* CHECK dout0_24 Vdout0_24ck106 = 1.1 time = 535
.meas tran vdout0_24ck106 FIND v(dout0_24) AT=535.025n

* CHECK dout0_25 Vdout0_25ck106 = 1.1 time = 535
.meas tran vdout0_25ck106 FIND v(dout0_25) AT=535.025n

* CHECK dout0_26 Vdout0_26ck106 = 1.1 time = 535
.meas tran vdout0_26ck106 FIND v(dout0_26) AT=535.025n

* CHECK dout0_27 Vdout0_27ck106 = 1.1 time = 535
.meas tran vdout0_27ck106 FIND v(dout0_27) AT=535.025n

* CHECK dout0_28 Vdout0_28ck106 = 1.1 time = 535
.meas tran vdout0_28ck106 FIND v(dout0_28) AT=535.025n

* CHECK dout0_29 Vdout0_29ck106 = 1.1 time = 535
.meas tran vdout0_29ck106 FIND v(dout0_29) AT=535.025n

* CHECK dout0_30 Vdout0_30ck106 = 0 time = 535
.meas tran vdout0_30ck106 FIND v(dout0_30) AT=535.025n

* CHECK dout0_31 Vdout0_31ck106 = 0 time = 535
.meas tran vdout0_31ck106 FIND v(dout0_31) AT=535.025n

* CHECK dout0_0 Vdout0_0ck107 = 1.1 time = 540
.meas tran vdout0_0ck107 FIND v(dout0_0) AT=540.025n

* CHECK dout0_1 Vdout0_1ck107 = 0 time = 540
.meas tran vdout0_1ck107 FIND v(dout0_1) AT=540.025n

* CHECK dout0_2 Vdout0_2ck107 = 1.1 time = 540
.meas tran vdout0_2ck107 FIND v(dout0_2) AT=540.025n

* CHECK dout0_3 Vdout0_3ck107 = 1.1 time = 540
.meas tran vdout0_3ck107 FIND v(dout0_3) AT=540.025n

* CHECK dout0_4 Vdout0_4ck107 = 0 time = 540
.meas tran vdout0_4ck107 FIND v(dout0_4) AT=540.025n

* CHECK dout0_5 Vdout0_5ck107 = 1.1 time = 540
.meas tran vdout0_5ck107 FIND v(dout0_5) AT=540.025n

* CHECK dout0_6 Vdout0_6ck107 = 1.1 time = 540
.meas tran vdout0_6ck107 FIND v(dout0_6) AT=540.025n

* CHECK dout0_7 Vdout0_7ck107 = 1.1 time = 540
.meas tran vdout0_7ck107 FIND v(dout0_7) AT=540.025n

* CHECK dout0_8 Vdout0_8ck107 = 0 time = 540
.meas tran vdout0_8ck107 FIND v(dout0_8) AT=540.025n

* CHECK dout0_9 Vdout0_9ck107 = 0 time = 540
.meas tran vdout0_9ck107 FIND v(dout0_9) AT=540.025n

* CHECK dout0_10 Vdout0_10ck107 = 0 time = 540
.meas tran vdout0_10ck107 FIND v(dout0_10) AT=540.025n

* CHECK dout0_11 Vdout0_11ck107 = 1.1 time = 540
.meas tran vdout0_11ck107 FIND v(dout0_11) AT=540.025n

* CHECK dout0_12 Vdout0_12ck107 = 1.1 time = 540
.meas tran vdout0_12ck107 FIND v(dout0_12) AT=540.025n

* CHECK dout0_13 Vdout0_13ck107 = 1.1 time = 540
.meas tran vdout0_13ck107 FIND v(dout0_13) AT=540.025n

* CHECK dout0_14 Vdout0_14ck107 = 1.1 time = 540
.meas tran vdout0_14ck107 FIND v(dout0_14) AT=540.025n

* CHECK dout0_15 Vdout0_15ck107 = 0 time = 540
.meas tran vdout0_15ck107 FIND v(dout0_15) AT=540.025n

* CHECK dout0_16 Vdout0_16ck107 = 1.1 time = 540
.meas tran vdout0_16ck107 FIND v(dout0_16) AT=540.025n

* CHECK dout0_17 Vdout0_17ck107 = 0 time = 540
.meas tran vdout0_17ck107 FIND v(dout0_17) AT=540.025n

* CHECK dout0_18 Vdout0_18ck107 = 1.1 time = 540
.meas tran vdout0_18ck107 FIND v(dout0_18) AT=540.025n

* CHECK dout0_19 Vdout0_19ck107 = 1.1 time = 540
.meas tran vdout0_19ck107 FIND v(dout0_19) AT=540.025n

* CHECK dout0_20 Vdout0_20ck107 = 0 time = 540
.meas tran vdout0_20ck107 FIND v(dout0_20) AT=540.025n

* CHECK dout0_21 Vdout0_21ck107 = 1.1 time = 540
.meas tran vdout0_21ck107 FIND v(dout0_21) AT=540.025n

* CHECK dout0_22 Vdout0_22ck107 = 1.1 time = 540
.meas tran vdout0_22ck107 FIND v(dout0_22) AT=540.025n

* CHECK dout0_23 Vdout0_23ck107 = 1.1 time = 540
.meas tran vdout0_23ck107 FIND v(dout0_23) AT=540.025n

* CHECK dout0_24 Vdout0_24ck107 = 1.1 time = 540
.meas tran vdout0_24ck107 FIND v(dout0_24) AT=540.025n

* CHECK dout0_25 Vdout0_25ck107 = 1.1 time = 540
.meas tran vdout0_25ck107 FIND v(dout0_25) AT=540.025n

* CHECK dout0_26 Vdout0_26ck107 = 1.1 time = 540
.meas tran vdout0_26ck107 FIND v(dout0_26) AT=540.025n

* CHECK dout0_27 Vdout0_27ck107 = 1.1 time = 540
.meas tran vdout0_27ck107 FIND v(dout0_27) AT=540.025n

* CHECK dout0_28 Vdout0_28ck107 = 1.1 time = 540
.meas tran vdout0_28ck107 FIND v(dout0_28) AT=540.025n

* CHECK dout0_29 Vdout0_29ck107 = 1.1 time = 540
.meas tran vdout0_29ck107 FIND v(dout0_29) AT=540.025n

* CHECK dout0_30 Vdout0_30ck107 = 0 time = 540
.meas tran vdout0_30ck107 FIND v(dout0_30) AT=540.025n

* CHECK dout0_31 Vdout0_31ck107 = 1.1 time = 540
.meas tran vdout0_31ck107 FIND v(dout0_31) AT=540.025n

* CHECK dout0_0 Vdout0_0ck108 = 0 time = 545
.meas tran vdout0_0ck108 FIND v(dout0_0) AT=545.025n

* CHECK dout0_1 Vdout0_1ck108 = 1.1 time = 545
.meas tran vdout0_1ck108 FIND v(dout0_1) AT=545.025n

* CHECK dout0_2 Vdout0_2ck108 = 0 time = 545
.meas tran vdout0_2ck108 FIND v(dout0_2) AT=545.025n

* CHECK dout0_3 Vdout0_3ck108 = 1.1 time = 545
.meas tran vdout0_3ck108 FIND v(dout0_3) AT=545.025n

* CHECK dout0_4 Vdout0_4ck108 = 1.1 time = 545
.meas tran vdout0_4ck108 FIND v(dout0_4) AT=545.025n

* CHECK dout0_5 Vdout0_5ck108 = 0 time = 545
.meas tran vdout0_5ck108 FIND v(dout0_5) AT=545.025n

* CHECK dout0_6 Vdout0_6ck108 = 1.1 time = 545
.meas tran vdout0_6ck108 FIND v(dout0_6) AT=545.025n

* CHECK dout0_7 Vdout0_7ck108 = 1.1 time = 545
.meas tran vdout0_7ck108 FIND v(dout0_7) AT=545.025n

* CHECK dout0_8 Vdout0_8ck108 = 0 time = 545
.meas tran vdout0_8ck108 FIND v(dout0_8) AT=545.025n

* CHECK dout0_9 Vdout0_9ck108 = 0 time = 545
.meas tran vdout0_9ck108 FIND v(dout0_9) AT=545.025n

* CHECK dout0_10 Vdout0_10ck108 = 0 time = 545
.meas tran vdout0_10ck108 FIND v(dout0_10) AT=545.025n

* CHECK dout0_11 Vdout0_11ck108 = 0 time = 545
.meas tran vdout0_11ck108 FIND v(dout0_11) AT=545.025n

* CHECK dout0_12 Vdout0_12ck108 = 0 time = 545
.meas tran vdout0_12ck108 FIND v(dout0_12) AT=545.025n

* CHECK dout0_13 Vdout0_13ck108 = 0 time = 545
.meas tran vdout0_13ck108 FIND v(dout0_13) AT=545.025n

* CHECK dout0_14 Vdout0_14ck108 = 1.1 time = 545
.meas tran vdout0_14ck108 FIND v(dout0_14) AT=545.025n

* CHECK dout0_15 Vdout0_15ck108 = 1.1 time = 545
.meas tran vdout0_15ck108 FIND v(dout0_15) AT=545.025n

* CHECK dout0_16 Vdout0_16ck108 = 1.1 time = 545
.meas tran vdout0_16ck108 FIND v(dout0_16) AT=545.025n

* CHECK dout0_17 Vdout0_17ck108 = 0 time = 545
.meas tran vdout0_17ck108 FIND v(dout0_17) AT=545.025n

* CHECK dout0_18 Vdout0_18ck108 = 0 time = 545
.meas tran vdout0_18ck108 FIND v(dout0_18) AT=545.025n

* CHECK dout0_19 Vdout0_19ck108 = 0 time = 545
.meas tran vdout0_19ck108 FIND v(dout0_19) AT=545.025n

* CHECK dout0_20 Vdout0_20ck108 = 1.1 time = 545
.meas tran vdout0_20ck108 FIND v(dout0_20) AT=545.025n

* CHECK dout0_21 Vdout0_21ck108 = 0 time = 545
.meas tran vdout0_21ck108 FIND v(dout0_21) AT=545.025n

* CHECK dout0_22 Vdout0_22ck108 = 1.1 time = 545
.meas tran vdout0_22ck108 FIND v(dout0_22) AT=545.025n

* CHECK dout0_23 Vdout0_23ck108 = 0 time = 545
.meas tran vdout0_23ck108 FIND v(dout0_23) AT=545.025n

* CHECK dout0_24 Vdout0_24ck108 = 0 time = 545
.meas tran vdout0_24ck108 FIND v(dout0_24) AT=545.025n

* CHECK dout0_25 Vdout0_25ck108 = 0 time = 545
.meas tran vdout0_25ck108 FIND v(dout0_25) AT=545.025n

* CHECK dout0_26 Vdout0_26ck108 = 1.1 time = 545
.meas tran vdout0_26ck108 FIND v(dout0_26) AT=545.025n

* CHECK dout0_27 Vdout0_27ck108 = 1.1 time = 545
.meas tran vdout0_27ck108 FIND v(dout0_27) AT=545.025n

* CHECK dout0_28 Vdout0_28ck108 = 0 time = 545
.meas tran vdout0_28ck108 FIND v(dout0_28) AT=545.025n

* CHECK dout0_29 Vdout0_29ck108 = 1.1 time = 545
.meas tran vdout0_29ck108 FIND v(dout0_29) AT=545.025n

* CHECK dout0_30 Vdout0_30ck108 = 0 time = 545
.meas tran vdout0_30ck108 FIND v(dout0_30) AT=545.025n

* CHECK dout0_31 Vdout0_31ck108 = 0 time = 545
.meas tran vdout0_31ck108 FIND v(dout0_31) AT=545.025n

* CHECK dout0_0 Vdout0_0ck109 = 1.1 time = 550
.meas tran vdout0_0ck109 FIND v(dout0_0) AT=550.025n

* CHECK dout0_1 Vdout0_1ck109 = 0 time = 550
.meas tran vdout0_1ck109 FIND v(dout0_1) AT=550.025n

* CHECK dout0_2 Vdout0_2ck109 = 1.1 time = 550
.meas tran vdout0_2ck109 FIND v(dout0_2) AT=550.025n

* CHECK dout0_3 Vdout0_3ck109 = 1.1 time = 550
.meas tran vdout0_3ck109 FIND v(dout0_3) AT=550.025n

* CHECK dout0_4 Vdout0_4ck109 = 0 time = 550
.meas tran vdout0_4ck109 FIND v(dout0_4) AT=550.025n

* CHECK dout0_5 Vdout0_5ck109 = 1.1 time = 550
.meas tran vdout0_5ck109 FIND v(dout0_5) AT=550.025n

* CHECK dout0_6 Vdout0_6ck109 = 1.1 time = 550
.meas tran vdout0_6ck109 FIND v(dout0_6) AT=550.025n

* CHECK dout0_7 Vdout0_7ck109 = 0 time = 550
.meas tran vdout0_7ck109 FIND v(dout0_7) AT=550.025n

* CHECK dout0_8 Vdout0_8ck109 = 1.1 time = 550
.meas tran vdout0_8ck109 FIND v(dout0_8) AT=550.025n

* CHECK dout0_9 Vdout0_9ck109 = 0 time = 550
.meas tran vdout0_9ck109 FIND v(dout0_9) AT=550.025n

* CHECK dout0_10 Vdout0_10ck109 = 1.1 time = 550
.meas tran vdout0_10ck109 FIND v(dout0_10) AT=550.025n

* CHECK dout0_11 Vdout0_11ck109 = 0 time = 550
.meas tran vdout0_11ck109 FIND v(dout0_11) AT=550.025n

* CHECK dout0_12 Vdout0_12ck109 = 1.1 time = 550
.meas tran vdout0_12ck109 FIND v(dout0_12) AT=550.025n

* CHECK dout0_13 Vdout0_13ck109 = 1.1 time = 550
.meas tran vdout0_13ck109 FIND v(dout0_13) AT=550.025n

* CHECK dout0_14 Vdout0_14ck109 = 1.1 time = 550
.meas tran vdout0_14ck109 FIND v(dout0_14) AT=550.025n

* CHECK dout0_15 Vdout0_15ck109 = 0 time = 550
.meas tran vdout0_15ck109 FIND v(dout0_15) AT=550.025n

* CHECK dout0_16 Vdout0_16ck109 = 0 time = 550
.meas tran vdout0_16ck109 FIND v(dout0_16) AT=550.025n

* CHECK dout0_17 Vdout0_17ck109 = 1.1 time = 550
.meas tran vdout0_17ck109 FIND v(dout0_17) AT=550.025n

* CHECK dout0_18 Vdout0_18ck109 = 0 time = 550
.meas tran vdout0_18ck109 FIND v(dout0_18) AT=550.025n

* CHECK dout0_19 Vdout0_19ck109 = 1.1 time = 550
.meas tran vdout0_19ck109 FIND v(dout0_19) AT=550.025n

* CHECK dout0_20 Vdout0_20ck109 = 0 time = 550
.meas tran vdout0_20ck109 FIND v(dout0_20) AT=550.025n

* CHECK dout0_21 Vdout0_21ck109 = 0 time = 550
.meas tran vdout0_21ck109 FIND v(dout0_21) AT=550.025n

* CHECK dout0_22 Vdout0_22ck109 = 0 time = 550
.meas tran vdout0_22ck109 FIND v(dout0_22) AT=550.025n

* CHECK dout0_23 Vdout0_23ck109 = 1.1 time = 550
.meas tran vdout0_23ck109 FIND v(dout0_23) AT=550.025n

* CHECK dout0_24 Vdout0_24ck109 = 1.1 time = 550
.meas tran vdout0_24ck109 FIND v(dout0_24) AT=550.025n

* CHECK dout0_25 Vdout0_25ck109 = 0 time = 550
.meas tran vdout0_25ck109 FIND v(dout0_25) AT=550.025n

* CHECK dout0_26 Vdout0_26ck109 = 1.1 time = 550
.meas tran vdout0_26ck109 FIND v(dout0_26) AT=550.025n

* CHECK dout0_27 Vdout0_27ck109 = 0 time = 550
.meas tran vdout0_27ck109 FIND v(dout0_27) AT=550.025n

* CHECK dout0_28 Vdout0_28ck109 = 1.1 time = 550
.meas tran vdout0_28ck109 FIND v(dout0_28) AT=550.025n

* CHECK dout0_29 Vdout0_29ck109 = 0 time = 550
.meas tran vdout0_29ck109 FIND v(dout0_29) AT=550.025n

* CHECK dout0_30 Vdout0_30ck109 = 1.1 time = 550
.meas tran vdout0_30ck109 FIND v(dout0_30) AT=550.025n

* CHECK dout0_31 Vdout0_31ck109 = 0 time = 550
.meas tran vdout0_31ck109 FIND v(dout0_31) AT=550.025n

* CHECK dout0_0 Vdout0_0ck110 = 1.1 time = 555
.meas tran vdout0_0ck110 FIND v(dout0_0) AT=555.025n

* CHECK dout0_1 Vdout0_1ck110 = 0 time = 555
.meas tran vdout0_1ck110 FIND v(dout0_1) AT=555.025n

* CHECK dout0_2 Vdout0_2ck110 = 1.1 time = 555
.meas tran vdout0_2ck110 FIND v(dout0_2) AT=555.025n

* CHECK dout0_3 Vdout0_3ck110 = 1.1 time = 555
.meas tran vdout0_3ck110 FIND v(dout0_3) AT=555.025n

* CHECK dout0_4 Vdout0_4ck110 = 0 time = 555
.meas tran vdout0_4ck110 FIND v(dout0_4) AT=555.025n

* CHECK dout0_5 Vdout0_5ck110 = 1.1 time = 555
.meas tran vdout0_5ck110 FIND v(dout0_5) AT=555.025n

* CHECK dout0_6 Vdout0_6ck110 = 1.1 time = 555
.meas tran vdout0_6ck110 FIND v(dout0_6) AT=555.025n

* CHECK dout0_7 Vdout0_7ck110 = 0 time = 555
.meas tran vdout0_7ck110 FIND v(dout0_7) AT=555.025n

* CHECK dout0_8 Vdout0_8ck110 = 1.1 time = 555
.meas tran vdout0_8ck110 FIND v(dout0_8) AT=555.025n

* CHECK dout0_9 Vdout0_9ck110 = 0 time = 555
.meas tran vdout0_9ck110 FIND v(dout0_9) AT=555.025n

* CHECK dout0_10 Vdout0_10ck110 = 1.1 time = 555
.meas tran vdout0_10ck110 FIND v(dout0_10) AT=555.025n

* CHECK dout0_11 Vdout0_11ck110 = 0 time = 555
.meas tran vdout0_11ck110 FIND v(dout0_11) AT=555.025n

* CHECK dout0_12 Vdout0_12ck110 = 1.1 time = 555
.meas tran vdout0_12ck110 FIND v(dout0_12) AT=555.025n

* CHECK dout0_13 Vdout0_13ck110 = 1.1 time = 555
.meas tran vdout0_13ck110 FIND v(dout0_13) AT=555.025n

* CHECK dout0_14 Vdout0_14ck110 = 1.1 time = 555
.meas tran vdout0_14ck110 FIND v(dout0_14) AT=555.025n

* CHECK dout0_15 Vdout0_15ck110 = 0 time = 555
.meas tran vdout0_15ck110 FIND v(dout0_15) AT=555.025n

* CHECK dout0_16 Vdout0_16ck110 = 0 time = 555
.meas tran vdout0_16ck110 FIND v(dout0_16) AT=555.025n

* CHECK dout0_17 Vdout0_17ck110 = 1.1 time = 555
.meas tran vdout0_17ck110 FIND v(dout0_17) AT=555.025n

* CHECK dout0_18 Vdout0_18ck110 = 0 time = 555
.meas tran vdout0_18ck110 FIND v(dout0_18) AT=555.025n

* CHECK dout0_19 Vdout0_19ck110 = 1.1 time = 555
.meas tran vdout0_19ck110 FIND v(dout0_19) AT=555.025n

* CHECK dout0_20 Vdout0_20ck110 = 0 time = 555
.meas tran vdout0_20ck110 FIND v(dout0_20) AT=555.025n

* CHECK dout0_21 Vdout0_21ck110 = 0 time = 555
.meas tran vdout0_21ck110 FIND v(dout0_21) AT=555.025n

* CHECK dout0_22 Vdout0_22ck110 = 0 time = 555
.meas tran vdout0_22ck110 FIND v(dout0_22) AT=555.025n

* CHECK dout0_23 Vdout0_23ck110 = 1.1 time = 555
.meas tran vdout0_23ck110 FIND v(dout0_23) AT=555.025n

* CHECK dout0_24 Vdout0_24ck110 = 1.1 time = 555
.meas tran vdout0_24ck110 FIND v(dout0_24) AT=555.025n

* CHECK dout0_25 Vdout0_25ck110 = 0 time = 555
.meas tran vdout0_25ck110 FIND v(dout0_25) AT=555.025n

* CHECK dout0_26 Vdout0_26ck110 = 1.1 time = 555
.meas tran vdout0_26ck110 FIND v(dout0_26) AT=555.025n

* CHECK dout0_27 Vdout0_27ck110 = 0 time = 555
.meas tran vdout0_27ck110 FIND v(dout0_27) AT=555.025n

* CHECK dout0_28 Vdout0_28ck110 = 1.1 time = 555
.meas tran vdout0_28ck110 FIND v(dout0_28) AT=555.025n

* CHECK dout0_29 Vdout0_29ck110 = 0 time = 555
.meas tran vdout0_29ck110 FIND v(dout0_29) AT=555.025n

* CHECK dout0_30 Vdout0_30ck110 = 1.1 time = 555
.meas tran vdout0_30ck110 FIND v(dout0_30) AT=555.025n

* CHECK dout0_31 Vdout0_31ck110 = 0 time = 555
.meas tran vdout0_31ck110 FIND v(dout0_31) AT=555.025n

* CHECK dout0_0 Vdout0_0ck111 = 0 time = 560
.meas tran vdout0_0ck111 FIND v(dout0_0) AT=560.025n

* CHECK dout0_1 Vdout0_1ck111 = 1.1 time = 560
.meas tran vdout0_1ck111 FIND v(dout0_1) AT=560.025n

* CHECK dout0_2 Vdout0_2ck111 = 1.1 time = 560
.meas tran vdout0_2ck111 FIND v(dout0_2) AT=560.025n

* CHECK dout0_3 Vdout0_3ck111 = 1.1 time = 560
.meas tran vdout0_3ck111 FIND v(dout0_3) AT=560.025n

* CHECK dout0_4 Vdout0_4ck111 = 0 time = 560
.meas tran vdout0_4ck111 FIND v(dout0_4) AT=560.025n

* CHECK dout0_5 Vdout0_5ck111 = 1.1 time = 560
.meas tran vdout0_5ck111 FIND v(dout0_5) AT=560.025n

* CHECK dout0_6 Vdout0_6ck111 = 0 time = 560
.meas tran vdout0_6ck111 FIND v(dout0_6) AT=560.025n

* CHECK dout0_7 Vdout0_7ck111 = 0 time = 560
.meas tran vdout0_7ck111 FIND v(dout0_7) AT=560.025n

* CHECK dout0_8 Vdout0_8ck111 = 1.1 time = 560
.meas tran vdout0_8ck111 FIND v(dout0_8) AT=560.025n

* CHECK dout0_9 Vdout0_9ck111 = 1.1 time = 560
.meas tran vdout0_9ck111 FIND v(dout0_9) AT=560.025n

* CHECK dout0_10 Vdout0_10ck111 = 1.1 time = 560
.meas tran vdout0_10ck111 FIND v(dout0_10) AT=560.025n

* CHECK dout0_11 Vdout0_11ck111 = 1.1 time = 560
.meas tran vdout0_11ck111 FIND v(dout0_11) AT=560.025n

* CHECK dout0_12 Vdout0_12ck111 = 0 time = 560
.meas tran vdout0_12ck111 FIND v(dout0_12) AT=560.025n

* CHECK dout0_13 Vdout0_13ck111 = 0 time = 560
.meas tran vdout0_13ck111 FIND v(dout0_13) AT=560.025n

* CHECK dout0_14 Vdout0_14ck111 = 0 time = 560
.meas tran vdout0_14ck111 FIND v(dout0_14) AT=560.025n

* CHECK dout0_15 Vdout0_15ck111 = 0 time = 560
.meas tran vdout0_15ck111 FIND v(dout0_15) AT=560.025n

* CHECK dout0_16 Vdout0_16ck111 = 0 time = 560
.meas tran vdout0_16ck111 FIND v(dout0_16) AT=560.025n

* CHECK dout0_17 Vdout0_17ck111 = 0 time = 560
.meas tran vdout0_17ck111 FIND v(dout0_17) AT=560.025n

* CHECK dout0_18 Vdout0_18ck111 = 0 time = 560
.meas tran vdout0_18ck111 FIND v(dout0_18) AT=560.025n

* CHECK dout0_19 Vdout0_19ck111 = 1.1 time = 560
.meas tran vdout0_19ck111 FIND v(dout0_19) AT=560.025n

* CHECK dout0_20 Vdout0_20ck111 = 1.1 time = 560
.meas tran vdout0_20ck111 FIND v(dout0_20) AT=560.025n

* CHECK dout0_21 Vdout0_21ck111 = 1.1 time = 560
.meas tran vdout0_21ck111 FIND v(dout0_21) AT=560.025n

* CHECK dout0_22 Vdout0_22ck111 = 1.1 time = 560
.meas tran vdout0_22ck111 FIND v(dout0_22) AT=560.025n

* CHECK dout0_23 Vdout0_23ck111 = 1.1 time = 560
.meas tran vdout0_23ck111 FIND v(dout0_23) AT=560.025n

* CHECK dout0_24 Vdout0_24ck111 = 1.1 time = 560
.meas tran vdout0_24ck111 FIND v(dout0_24) AT=560.025n

* CHECK dout0_25 Vdout0_25ck111 = 0 time = 560
.meas tran vdout0_25ck111 FIND v(dout0_25) AT=560.025n

* CHECK dout0_26 Vdout0_26ck111 = 1.1 time = 560
.meas tran vdout0_26ck111 FIND v(dout0_26) AT=560.025n

* CHECK dout0_27 Vdout0_27ck111 = 1.1 time = 560
.meas tran vdout0_27ck111 FIND v(dout0_27) AT=560.025n

* CHECK dout0_28 Vdout0_28ck111 = 1.1 time = 560
.meas tran vdout0_28ck111 FIND v(dout0_28) AT=560.025n

* CHECK dout0_29 Vdout0_29ck111 = 0 time = 560
.meas tran vdout0_29ck111 FIND v(dout0_29) AT=560.025n

* CHECK dout0_30 Vdout0_30ck111 = 1.1 time = 560
.meas tran vdout0_30ck111 FIND v(dout0_30) AT=560.025n

* CHECK dout0_31 Vdout0_31ck111 = 1.1 time = 560
.meas tran vdout0_31ck111 FIND v(dout0_31) AT=560.025n

* CHECK dout0_0 Vdout0_0ck112 = 0 time = 565
.meas tran vdout0_0ck112 FIND v(dout0_0) AT=565.025n

* CHECK dout0_1 Vdout0_1ck112 = 1.1 time = 565
.meas tran vdout0_1ck112 FIND v(dout0_1) AT=565.025n

* CHECK dout0_2 Vdout0_2ck112 = 0 time = 565
.meas tran vdout0_2ck112 FIND v(dout0_2) AT=565.025n

* CHECK dout0_3 Vdout0_3ck112 = 1.1 time = 565
.meas tran vdout0_3ck112 FIND v(dout0_3) AT=565.025n

* CHECK dout0_4 Vdout0_4ck112 = 0 time = 565
.meas tran vdout0_4ck112 FIND v(dout0_4) AT=565.025n

* CHECK dout0_5 Vdout0_5ck112 = 0 time = 565
.meas tran vdout0_5ck112 FIND v(dout0_5) AT=565.025n

* CHECK dout0_6 Vdout0_6ck112 = 1.1 time = 565
.meas tran vdout0_6ck112 FIND v(dout0_6) AT=565.025n

* CHECK dout0_7 Vdout0_7ck112 = 0 time = 565
.meas tran vdout0_7ck112 FIND v(dout0_7) AT=565.025n

* CHECK dout0_8 Vdout0_8ck112 = 0 time = 565
.meas tran vdout0_8ck112 FIND v(dout0_8) AT=565.025n

* CHECK dout0_9 Vdout0_9ck112 = 0 time = 565
.meas tran vdout0_9ck112 FIND v(dout0_9) AT=565.025n

* CHECK dout0_10 Vdout0_10ck112 = 0 time = 565
.meas tran vdout0_10ck112 FIND v(dout0_10) AT=565.025n

* CHECK dout0_11 Vdout0_11ck112 = 0 time = 565
.meas tran vdout0_11ck112 FIND v(dout0_11) AT=565.025n

* CHECK dout0_12 Vdout0_12ck112 = 0 time = 565
.meas tran vdout0_12ck112 FIND v(dout0_12) AT=565.025n

* CHECK dout0_13 Vdout0_13ck112 = 0 time = 565
.meas tran vdout0_13ck112 FIND v(dout0_13) AT=565.025n

* CHECK dout0_14 Vdout0_14ck112 = 0 time = 565
.meas tran vdout0_14ck112 FIND v(dout0_14) AT=565.025n

* CHECK dout0_15 Vdout0_15ck112 = 0 time = 565
.meas tran vdout0_15ck112 FIND v(dout0_15) AT=565.025n

* CHECK dout0_16 Vdout0_16ck112 = 0 time = 565
.meas tran vdout0_16ck112 FIND v(dout0_16) AT=565.025n

* CHECK dout0_17 Vdout0_17ck112 = 1.1 time = 565
.meas tran vdout0_17ck112 FIND v(dout0_17) AT=565.025n

* CHECK dout0_18 Vdout0_18ck112 = 1.1 time = 565
.meas tran vdout0_18ck112 FIND v(dout0_18) AT=565.025n

* CHECK dout0_19 Vdout0_19ck112 = 1.1 time = 565
.meas tran vdout0_19ck112 FIND v(dout0_19) AT=565.025n

* CHECK dout0_20 Vdout0_20ck112 = 0 time = 565
.meas tran vdout0_20ck112 FIND v(dout0_20) AT=565.025n

* CHECK dout0_21 Vdout0_21ck112 = 0 time = 565
.meas tran vdout0_21ck112 FIND v(dout0_21) AT=565.025n

* CHECK dout0_22 Vdout0_22ck112 = 0 time = 565
.meas tran vdout0_22ck112 FIND v(dout0_22) AT=565.025n

* CHECK dout0_23 Vdout0_23ck112 = 1.1 time = 565
.meas tran vdout0_23ck112 FIND v(dout0_23) AT=565.025n

* CHECK dout0_24 Vdout0_24ck112 = 0 time = 565
.meas tran vdout0_24ck112 FIND v(dout0_24) AT=565.025n

* CHECK dout0_25 Vdout0_25ck112 = 1.1 time = 565
.meas tran vdout0_25ck112 FIND v(dout0_25) AT=565.025n

* CHECK dout0_26 Vdout0_26ck112 = 0 time = 565
.meas tran vdout0_26ck112 FIND v(dout0_26) AT=565.025n

* CHECK dout0_27 Vdout0_27ck112 = 0 time = 565
.meas tran vdout0_27ck112 FIND v(dout0_27) AT=565.025n

* CHECK dout0_28 Vdout0_28ck112 = 1.1 time = 565
.meas tran vdout0_28ck112 FIND v(dout0_28) AT=565.025n

* CHECK dout0_29 Vdout0_29ck112 = 1.1 time = 565
.meas tran vdout0_29ck112 FIND v(dout0_29) AT=565.025n

* CHECK dout0_30 Vdout0_30ck112 = 0 time = 565
.meas tran vdout0_30ck112 FIND v(dout0_30) AT=565.025n

* CHECK dout0_31 Vdout0_31ck112 = 1.1 time = 565
.meas tran vdout0_31ck112 FIND v(dout0_31) AT=565.025n

* CHECK dout0_0 Vdout0_0ck113 = 1.1 time = 570
.meas tran vdout0_0ck113 FIND v(dout0_0) AT=570.025n

* CHECK dout0_1 Vdout0_1ck113 = 0 time = 570
.meas tran vdout0_1ck113 FIND v(dout0_1) AT=570.025n

* CHECK dout0_2 Vdout0_2ck113 = 1.1 time = 570
.meas tran vdout0_2ck113 FIND v(dout0_2) AT=570.025n

* CHECK dout0_3 Vdout0_3ck113 = 1.1 time = 570
.meas tran vdout0_3ck113 FIND v(dout0_3) AT=570.025n

* CHECK dout0_4 Vdout0_4ck113 = 0 time = 570
.meas tran vdout0_4ck113 FIND v(dout0_4) AT=570.025n

* CHECK dout0_5 Vdout0_5ck113 = 1.1 time = 570
.meas tran vdout0_5ck113 FIND v(dout0_5) AT=570.025n

* CHECK dout0_6 Vdout0_6ck113 = 1.1 time = 570
.meas tran vdout0_6ck113 FIND v(dout0_6) AT=570.025n

* CHECK dout0_7 Vdout0_7ck113 = 0 time = 570
.meas tran vdout0_7ck113 FIND v(dout0_7) AT=570.025n

* CHECK dout0_8 Vdout0_8ck113 = 1.1 time = 570
.meas tran vdout0_8ck113 FIND v(dout0_8) AT=570.025n

* CHECK dout0_9 Vdout0_9ck113 = 0 time = 570
.meas tran vdout0_9ck113 FIND v(dout0_9) AT=570.025n

* CHECK dout0_10 Vdout0_10ck113 = 1.1 time = 570
.meas tran vdout0_10ck113 FIND v(dout0_10) AT=570.025n

* CHECK dout0_11 Vdout0_11ck113 = 0 time = 570
.meas tran vdout0_11ck113 FIND v(dout0_11) AT=570.025n

* CHECK dout0_12 Vdout0_12ck113 = 1.1 time = 570
.meas tran vdout0_12ck113 FIND v(dout0_12) AT=570.025n

* CHECK dout0_13 Vdout0_13ck113 = 1.1 time = 570
.meas tran vdout0_13ck113 FIND v(dout0_13) AT=570.025n

* CHECK dout0_14 Vdout0_14ck113 = 1.1 time = 570
.meas tran vdout0_14ck113 FIND v(dout0_14) AT=570.025n

* CHECK dout0_15 Vdout0_15ck113 = 0 time = 570
.meas tran vdout0_15ck113 FIND v(dout0_15) AT=570.025n

* CHECK dout0_16 Vdout0_16ck113 = 0 time = 570
.meas tran vdout0_16ck113 FIND v(dout0_16) AT=570.025n

* CHECK dout0_17 Vdout0_17ck113 = 1.1 time = 570
.meas tran vdout0_17ck113 FIND v(dout0_17) AT=570.025n

* CHECK dout0_18 Vdout0_18ck113 = 0 time = 570
.meas tran vdout0_18ck113 FIND v(dout0_18) AT=570.025n

* CHECK dout0_19 Vdout0_19ck113 = 1.1 time = 570
.meas tran vdout0_19ck113 FIND v(dout0_19) AT=570.025n

* CHECK dout0_20 Vdout0_20ck113 = 0 time = 570
.meas tran vdout0_20ck113 FIND v(dout0_20) AT=570.025n

* CHECK dout0_21 Vdout0_21ck113 = 0 time = 570
.meas tran vdout0_21ck113 FIND v(dout0_21) AT=570.025n

* CHECK dout0_22 Vdout0_22ck113 = 0 time = 570
.meas tran vdout0_22ck113 FIND v(dout0_22) AT=570.025n

* CHECK dout0_23 Vdout0_23ck113 = 1.1 time = 570
.meas tran vdout0_23ck113 FIND v(dout0_23) AT=570.025n

* CHECK dout0_24 Vdout0_24ck113 = 1.1 time = 570
.meas tran vdout0_24ck113 FIND v(dout0_24) AT=570.025n

* CHECK dout0_25 Vdout0_25ck113 = 0 time = 570
.meas tran vdout0_25ck113 FIND v(dout0_25) AT=570.025n

* CHECK dout0_26 Vdout0_26ck113 = 1.1 time = 570
.meas tran vdout0_26ck113 FIND v(dout0_26) AT=570.025n

* CHECK dout0_27 Vdout0_27ck113 = 0 time = 570
.meas tran vdout0_27ck113 FIND v(dout0_27) AT=570.025n

* CHECK dout0_28 Vdout0_28ck113 = 1.1 time = 570
.meas tran vdout0_28ck113 FIND v(dout0_28) AT=570.025n

* CHECK dout0_29 Vdout0_29ck113 = 0 time = 570
.meas tran vdout0_29ck113 FIND v(dout0_29) AT=570.025n

* CHECK dout0_30 Vdout0_30ck113 = 1.1 time = 570
.meas tran vdout0_30ck113 FIND v(dout0_30) AT=570.025n

* CHECK dout0_31 Vdout0_31ck113 = 0 time = 570
.meas tran vdout0_31ck113 FIND v(dout0_31) AT=570.025n

* CHECK dout0_0 Vdout0_0ck114 = 0 time = 575
.meas tran vdout0_0ck114 FIND v(dout0_0) AT=575.025n

* CHECK dout0_1 Vdout0_1ck114 = 0 time = 575
.meas tran vdout0_1ck114 FIND v(dout0_1) AT=575.025n

* CHECK dout0_2 Vdout0_2ck114 = 0 time = 575
.meas tran vdout0_2ck114 FIND v(dout0_2) AT=575.025n

* CHECK dout0_3 Vdout0_3ck114 = 1.1 time = 575
.meas tran vdout0_3ck114 FIND v(dout0_3) AT=575.025n

* CHECK dout0_4 Vdout0_4ck114 = 1.1 time = 575
.meas tran vdout0_4ck114 FIND v(dout0_4) AT=575.025n

* CHECK dout0_5 Vdout0_5ck114 = 1.1 time = 575
.meas tran vdout0_5ck114 FIND v(dout0_5) AT=575.025n

* CHECK dout0_6 Vdout0_6ck114 = 1.1 time = 575
.meas tran vdout0_6ck114 FIND v(dout0_6) AT=575.025n

* CHECK dout0_7 Vdout0_7ck114 = 1.1 time = 575
.meas tran vdout0_7ck114 FIND v(dout0_7) AT=575.025n

* CHECK dout0_8 Vdout0_8ck114 = 1.1 time = 575
.meas tran vdout0_8ck114 FIND v(dout0_8) AT=575.025n

* CHECK dout0_9 Vdout0_9ck114 = 0 time = 575
.meas tran vdout0_9ck114 FIND v(dout0_9) AT=575.025n

* CHECK dout0_10 Vdout0_10ck114 = 1.1 time = 575
.meas tran vdout0_10ck114 FIND v(dout0_10) AT=575.025n

* CHECK dout0_11 Vdout0_11ck114 = 0 time = 575
.meas tran vdout0_11ck114 FIND v(dout0_11) AT=575.025n

* CHECK dout0_12 Vdout0_12ck114 = 0 time = 575
.meas tran vdout0_12ck114 FIND v(dout0_12) AT=575.025n

* CHECK dout0_13 Vdout0_13ck114 = 0 time = 575
.meas tran vdout0_13ck114 FIND v(dout0_13) AT=575.025n

* CHECK dout0_14 Vdout0_14ck114 = 0 time = 575
.meas tran vdout0_14ck114 FIND v(dout0_14) AT=575.025n

* CHECK dout0_15 Vdout0_15ck114 = 0 time = 575
.meas tran vdout0_15ck114 FIND v(dout0_15) AT=575.025n

* CHECK dout0_16 Vdout0_16ck114 = 0 time = 575
.meas tran vdout0_16ck114 FIND v(dout0_16) AT=575.025n

* CHECK dout0_17 Vdout0_17ck114 = 1.1 time = 575
.meas tran vdout0_17ck114 FIND v(dout0_17) AT=575.025n

* CHECK dout0_18 Vdout0_18ck114 = 0 time = 575
.meas tran vdout0_18ck114 FIND v(dout0_18) AT=575.025n

* CHECK dout0_19 Vdout0_19ck114 = 0 time = 575
.meas tran vdout0_19ck114 FIND v(dout0_19) AT=575.025n

* CHECK dout0_20 Vdout0_20ck114 = 1.1 time = 575
.meas tran vdout0_20ck114 FIND v(dout0_20) AT=575.025n

* CHECK dout0_21 Vdout0_21ck114 = 1.1 time = 575
.meas tran vdout0_21ck114 FIND v(dout0_21) AT=575.025n

* CHECK dout0_22 Vdout0_22ck114 = 0 time = 575
.meas tran vdout0_22ck114 FIND v(dout0_22) AT=575.025n

* CHECK dout0_23 Vdout0_23ck114 = 1.1 time = 575
.meas tran vdout0_23ck114 FIND v(dout0_23) AT=575.025n

* CHECK dout0_24 Vdout0_24ck114 = 1.1 time = 575
.meas tran vdout0_24ck114 FIND v(dout0_24) AT=575.025n

* CHECK dout0_25 Vdout0_25ck114 = 1.1 time = 575
.meas tran vdout0_25ck114 FIND v(dout0_25) AT=575.025n

* CHECK dout0_26 Vdout0_26ck114 = 0 time = 575
.meas tran vdout0_26ck114 FIND v(dout0_26) AT=575.025n

* CHECK dout0_27 Vdout0_27ck114 = 0 time = 575
.meas tran vdout0_27ck114 FIND v(dout0_27) AT=575.025n

* CHECK dout0_28 Vdout0_28ck114 = 0 time = 575
.meas tran vdout0_28ck114 FIND v(dout0_28) AT=575.025n

* CHECK dout0_29 Vdout0_29ck114 = 1.1 time = 575
.meas tran vdout0_29ck114 FIND v(dout0_29) AT=575.025n

* CHECK dout0_30 Vdout0_30ck114 = 0 time = 575
.meas tran vdout0_30ck114 FIND v(dout0_30) AT=575.025n

* CHECK dout0_31 Vdout0_31ck114 = 0 time = 575
.meas tran vdout0_31ck114 FIND v(dout0_31) AT=575.025n

* CHECK dout0_0 Vdout0_0ck115 = 0 time = 580
.meas tran vdout0_0ck115 FIND v(dout0_0) AT=580.025n

* CHECK dout0_1 Vdout0_1ck115 = 0 time = 580
.meas tran vdout0_1ck115 FIND v(dout0_1) AT=580.025n

* CHECK dout0_2 Vdout0_2ck115 = 0 time = 580
.meas tran vdout0_2ck115 FIND v(dout0_2) AT=580.025n

* CHECK dout0_3 Vdout0_3ck115 = 1.1 time = 580
.meas tran vdout0_3ck115 FIND v(dout0_3) AT=580.025n

* CHECK dout0_4 Vdout0_4ck115 = 1.1 time = 580
.meas tran vdout0_4ck115 FIND v(dout0_4) AT=580.025n

* CHECK dout0_5 Vdout0_5ck115 = 1.1 time = 580
.meas tran vdout0_5ck115 FIND v(dout0_5) AT=580.025n

* CHECK dout0_6 Vdout0_6ck115 = 1.1 time = 580
.meas tran vdout0_6ck115 FIND v(dout0_6) AT=580.025n

* CHECK dout0_7 Vdout0_7ck115 = 1.1 time = 580
.meas tran vdout0_7ck115 FIND v(dout0_7) AT=580.025n

* CHECK dout0_8 Vdout0_8ck115 = 1.1 time = 580
.meas tran vdout0_8ck115 FIND v(dout0_8) AT=580.025n

* CHECK dout0_9 Vdout0_9ck115 = 0 time = 580
.meas tran vdout0_9ck115 FIND v(dout0_9) AT=580.025n

* CHECK dout0_10 Vdout0_10ck115 = 1.1 time = 580
.meas tran vdout0_10ck115 FIND v(dout0_10) AT=580.025n

* CHECK dout0_11 Vdout0_11ck115 = 0 time = 580
.meas tran vdout0_11ck115 FIND v(dout0_11) AT=580.025n

* CHECK dout0_12 Vdout0_12ck115 = 0 time = 580
.meas tran vdout0_12ck115 FIND v(dout0_12) AT=580.025n

* CHECK dout0_13 Vdout0_13ck115 = 0 time = 580
.meas tran vdout0_13ck115 FIND v(dout0_13) AT=580.025n

* CHECK dout0_14 Vdout0_14ck115 = 0 time = 580
.meas tran vdout0_14ck115 FIND v(dout0_14) AT=580.025n

* CHECK dout0_15 Vdout0_15ck115 = 0 time = 580
.meas tran vdout0_15ck115 FIND v(dout0_15) AT=580.025n

* CHECK dout0_16 Vdout0_16ck115 = 0 time = 580
.meas tran vdout0_16ck115 FIND v(dout0_16) AT=580.025n

* CHECK dout0_17 Vdout0_17ck115 = 1.1 time = 580
.meas tran vdout0_17ck115 FIND v(dout0_17) AT=580.025n

* CHECK dout0_18 Vdout0_18ck115 = 0 time = 580
.meas tran vdout0_18ck115 FIND v(dout0_18) AT=580.025n

* CHECK dout0_19 Vdout0_19ck115 = 0 time = 580
.meas tran vdout0_19ck115 FIND v(dout0_19) AT=580.025n

* CHECK dout0_20 Vdout0_20ck115 = 1.1 time = 580
.meas tran vdout0_20ck115 FIND v(dout0_20) AT=580.025n

* CHECK dout0_21 Vdout0_21ck115 = 1.1 time = 580
.meas tran vdout0_21ck115 FIND v(dout0_21) AT=580.025n

* CHECK dout0_22 Vdout0_22ck115 = 0 time = 580
.meas tran vdout0_22ck115 FIND v(dout0_22) AT=580.025n

* CHECK dout0_23 Vdout0_23ck115 = 1.1 time = 580
.meas tran vdout0_23ck115 FIND v(dout0_23) AT=580.025n

* CHECK dout0_24 Vdout0_24ck115 = 1.1 time = 580
.meas tran vdout0_24ck115 FIND v(dout0_24) AT=580.025n

* CHECK dout0_25 Vdout0_25ck115 = 1.1 time = 580
.meas tran vdout0_25ck115 FIND v(dout0_25) AT=580.025n

* CHECK dout0_26 Vdout0_26ck115 = 0 time = 580
.meas tran vdout0_26ck115 FIND v(dout0_26) AT=580.025n

* CHECK dout0_27 Vdout0_27ck115 = 0 time = 580
.meas tran vdout0_27ck115 FIND v(dout0_27) AT=580.025n

* CHECK dout0_28 Vdout0_28ck115 = 0 time = 580
.meas tran vdout0_28ck115 FIND v(dout0_28) AT=580.025n

* CHECK dout0_29 Vdout0_29ck115 = 1.1 time = 580
.meas tran vdout0_29ck115 FIND v(dout0_29) AT=580.025n

* CHECK dout0_30 Vdout0_30ck115 = 0 time = 580
.meas tran vdout0_30ck115 FIND v(dout0_30) AT=580.025n

* CHECK dout0_31 Vdout0_31ck115 = 0 time = 580
.meas tran vdout0_31ck115 FIND v(dout0_31) AT=580.025n

* CHECK dout0_0 Vdout0_0ck116 = 0 time = 585
.meas tran vdout0_0ck116 FIND v(dout0_0) AT=585.025n

* CHECK dout0_1 Vdout0_1ck116 = 0 time = 585
.meas tran vdout0_1ck116 FIND v(dout0_1) AT=585.025n

* CHECK dout0_2 Vdout0_2ck116 = 0 time = 585
.meas tran vdout0_2ck116 FIND v(dout0_2) AT=585.025n

* CHECK dout0_3 Vdout0_3ck116 = 1.1 time = 585
.meas tran vdout0_3ck116 FIND v(dout0_3) AT=585.025n

* CHECK dout0_4 Vdout0_4ck116 = 1.1 time = 585
.meas tran vdout0_4ck116 FIND v(dout0_4) AT=585.025n

* CHECK dout0_5 Vdout0_5ck116 = 1.1 time = 585
.meas tran vdout0_5ck116 FIND v(dout0_5) AT=585.025n

* CHECK dout0_6 Vdout0_6ck116 = 1.1 time = 585
.meas tran vdout0_6ck116 FIND v(dout0_6) AT=585.025n

* CHECK dout0_7 Vdout0_7ck116 = 1.1 time = 585
.meas tran vdout0_7ck116 FIND v(dout0_7) AT=585.025n

* CHECK dout0_8 Vdout0_8ck116 = 1.1 time = 585
.meas tran vdout0_8ck116 FIND v(dout0_8) AT=585.025n

* CHECK dout0_9 Vdout0_9ck116 = 0 time = 585
.meas tran vdout0_9ck116 FIND v(dout0_9) AT=585.025n

* CHECK dout0_10 Vdout0_10ck116 = 1.1 time = 585
.meas tran vdout0_10ck116 FIND v(dout0_10) AT=585.025n

* CHECK dout0_11 Vdout0_11ck116 = 0 time = 585
.meas tran vdout0_11ck116 FIND v(dout0_11) AT=585.025n

* CHECK dout0_12 Vdout0_12ck116 = 0 time = 585
.meas tran vdout0_12ck116 FIND v(dout0_12) AT=585.025n

* CHECK dout0_13 Vdout0_13ck116 = 0 time = 585
.meas tran vdout0_13ck116 FIND v(dout0_13) AT=585.025n

* CHECK dout0_14 Vdout0_14ck116 = 0 time = 585
.meas tran vdout0_14ck116 FIND v(dout0_14) AT=585.025n

* CHECK dout0_15 Vdout0_15ck116 = 0 time = 585
.meas tran vdout0_15ck116 FIND v(dout0_15) AT=585.025n

* CHECK dout0_16 Vdout0_16ck116 = 0 time = 585
.meas tran vdout0_16ck116 FIND v(dout0_16) AT=585.025n

* CHECK dout0_17 Vdout0_17ck116 = 1.1 time = 585
.meas tran vdout0_17ck116 FIND v(dout0_17) AT=585.025n

* CHECK dout0_18 Vdout0_18ck116 = 0 time = 585
.meas tran vdout0_18ck116 FIND v(dout0_18) AT=585.025n

* CHECK dout0_19 Vdout0_19ck116 = 0 time = 585
.meas tran vdout0_19ck116 FIND v(dout0_19) AT=585.025n

* CHECK dout0_20 Vdout0_20ck116 = 1.1 time = 585
.meas tran vdout0_20ck116 FIND v(dout0_20) AT=585.025n

* CHECK dout0_21 Vdout0_21ck116 = 1.1 time = 585
.meas tran vdout0_21ck116 FIND v(dout0_21) AT=585.025n

* CHECK dout0_22 Vdout0_22ck116 = 0 time = 585
.meas tran vdout0_22ck116 FIND v(dout0_22) AT=585.025n

* CHECK dout0_23 Vdout0_23ck116 = 1.1 time = 585
.meas tran vdout0_23ck116 FIND v(dout0_23) AT=585.025n

* CHECK dout0_24 Vdout0_24ck116 = 1.1 time = 585
.meas tran vdout0_24ck116 FIND v(dout0_24) AT=585.025n

* CHECK dout0_25 Vdout0_25ck116 = 1.1 time = 585
.meas tran vdout0_25ck116 FIND v(dout0_25) AT=585.025n

* CHECK dout0_26 Vdout0_26ck116 = 0 time = 585
.meas tran vdout0_26ck116 FIND v(dout0_26) AT=585.025n

* CHECK dout0_27 Vdout0_27ck116 = 0 time = 585
.meas tran vdout0_27ck116 FIND v(dout0_27) AT=585.025n

* CHECK dout0_28 Vdout0_28ck116 = 0 time = 585
.meas tran vdout0_28ck116 FIND v(dout0_28) AT=585.025n

* CHECK dout0_29 Vdout0_29ck116 = 1.1 time = 585
.meas tran vdout0_29ck116 FIND v(dout0_29) AT=585.025n

* CHECK dout0_30 Vdout0_30ck116 = 0 time = 585
.meas tran vdout0_30ck116 FIND v(dout0_30) AT=585.025n

* CHECK dout0_31 Vdout0_31ck116 = 0 time = 585
.meas tran vdout0_31ck116 FIND v(dout0_31) AT=585.025n

* CHECK dout0_0 Vdout0_0ck119 = 0 time = 600
.meas tran vdout0_0ck119 FIND v(dout0_0) AT=600.025n

* CHECK dout0_1 Vdout0_1ck119 = 1.1 time = 600
.meas tran vdout0_1ck119 FIND v(dout0_1) AT=600.025n

* CHECK dout0_2 Vdout0_2ck119 = 0 time = 600
.meas tran vdout0_2ck119 FIND v(dout0_2) AT=600.025n

* CHECK dout0_3 Vdout0_3ck119 = 1.1 time = 600
.meas tran vdout0_3ck119 FIND v(dout0_3) AT=600.025n

* CHECK dout0_4 Vdout0_4ck119 = 1.1 time = 600
.meas tran vdout0_4ck119 FIND v(dout0_4) AT=600.025n

* CHECK dout0_5 Vdout0_5ck119 = 0 time = 600
.meas tran vdout0_5ck119 FIND v(dout0_5) AT=600.025n

* CHECK dout0_6 Vdout0_6ck119 = 1.1 time = 600
.meas tran vdout0_6ck119 FIND v(dout0_6) AT=600.025n

* CHECK dout0_7 Vdout0_7ck119 = 1.1 time = 600
.meas tran vdout0_7ck119 FIND v(dout0_7) AT=600.025n

* CHECK dout0_8 Vdout0_8ck119 = 0 time = 600
.meas tran vdout0_8ck119 FIND v(dout0_8) AT=600.025n

* CHECK dout0_9 Vdout0_9ck119 = 0 time = 600
.meas tran vdout0_9ck119 FIND v(dout0_9) AT=600.025n

* CHECK dout0_10 Vdout0_10ck119 = 0 time = 600
.meas tran vdout0_10ck119 FIND v(dout0_10) AT=600.025n

* CHECK dout0_11 Vdout0_11ck119 = 0 time = 600
.meas tran vdout0_11ck119 FIND v(dout0_11) AT=600.025n

* CHECK dout0_12 Vdout0_12ck119 = 0 time = 600
.meas tran vdout0_12ck119 FIND v(dout0_12) AT=600.025n

* CHECK dout0_13 Vdout0_13ck119 = 0 time = 600
.meas tran vdout0_13ck119 FIND v(dout0_13) AT=600.025n

* CHECK dout0_14 Vdout0_14ck119 = 1.1 time = 600
.meas tran vdout0_14ck119 FIND v(dout0_14) AT=600.025n

* CHECK dout0_15 Vdout0_15ck119 = 1.1 time = 600
.meas tran vdout0_15ck119 FIND v(dout0_15) AT=600.025n

* CHECK dout0_16 Vdout0_16ck119 = 1.1 time = 600
.meas tran vdout0_16ck119 FIND v(dout0_16) AT=600.025n

* CHECK dout0_17 Vdout0_17ck119 = 0 time = 600
.meas tran vdout0_17ck119 FIND v(dout0_17) AT=600.025n

* CHECK dout0_18 Vdout0_18ck119 = 0 time = 600
.meas tran vdout0_18ck119 FIND v(dout0_18) AT=600.025n

* CHECK dout0_19 Vdout0_19ck119 = 0 time = 600
.meas tran vdout0_19ck119 FIND v(dout0_19) AT=600.025n

* CHECK dout0_20 Vdout0_20ck119 = 1.1 time = 600
.meas tran vdout0_20ck119 FIND v(dout0_20) AT=600.025n

* CHECK dout0_21 Vdout0_21ck119 = 0 time = 600
.meas tran vdout0_21ck119 FIND v(dout0_21) AT=600.025n

* CHECK dout0_22 Vdout0_22ck119 = 1.1 time = 600
.meas tran vdout0_22ck119 FIND v(dout0_22) AT=600.025n

* CHECK dout0_23 Vdout0_23ck119 = 0 time = 600
.meas tran vdout0_23ck119 FIND v(dout0_23) AT=600.025n

* CHECK dout0_24 Vdout0_24ck119 = 0 time = 600
.meas tran vdout0_24ck119 FIND v(dout0_24) AT=600.025n

* CHECK dout0_25 Vdout0_25ck119 = 0 time = 600
.meas tran vdout0_25ck119 FIND v(dout0_25) AT=600.025n

* CHECK dout0_26 Vdout0_26ck119 = 1.1 time = 600
.meas tran vdout0_26ck119 FIND v(dout0_26) AT=600.025n

* CHECK dout0_27 Vdout0_27ck119 = 1.1 time = 600
.meas tran vdout0_27ck119 FIND v(dout0_27) AT=600.025n

* CHECK dout0_28 Vdout0_28ck119 = 0 time = 600
.meas tran vdout0_28ck119 FIND v(dout0_28) AT=600.025n

* CHECK dout0_29 Vdout0_29ck119 = 1.1 time = 600
.meas tran vdout0_29ck119 FIND v(dout0_29) AT=600.025n

* CHECK dout0_30 Vdout0_30ck119 = 0 time = 600
.meas tran vdout0_30ck119 FIND v(dout0_30) AT=600.025n

* CHECK dout0_31 Vdout0_31ck119 = 0 time = 600
.meas tran vdout0_31ck119 FIND v(dout0_31) AT=600.025n

* CHECK dout0_0 Vdout0_0ck121 = 0 time = 610
.meas tran vdout0_0ck121 FIND v(dout0_0) AT=610.025n

* CHECK dout0_1 Vdout0_1ck121 = 1.1 time = 610
.meas tran vdout0_1ck121 FIND v(dout0_1) AT=610.025n

* CHECK dout0_2 Vdout0_2ck121 = 1.1 time = 610
.meas tran vdout0_2ck121 FIND v(dout0_2) AT=610.025n

* CHECK dout0_3 Vdout0_3ck121 = 1.1 time = 610
.meas tran vdout0_3ck121 FIND v(dout0_3) AT=610.025n

* CHECK dout0_4 Vdout0_4ck121 = 0 time = 610
.meas tran vdout0_4ck121 FIND v(dout0_4) AT=610.025n

* CHECK dout0_5 Vdout0_5ck121 = 1.1 time = 610
.meas tran vdout0_5ck121 FIND v(dout0_5) AT=610.025n

* CHECK dout0_6 Vdout0_6ck121 = 0 time = 610
.meas tran vdout0_6ck121 FIND v(dout0_6) AT=610.025n

* CHECK dout0_7 Vdout0_7ck121 = 0 time = 610
.meas tran vdout0_7ck121 FIND v(dout0_7) AT=610.025n

* CHECK dout0_8 Vdout0_8ck121 = 1.1 time = 610
.meas tran vdout0_8ck121 FIND v(dout0_8) AT=610.025n

* CHECK dout0_9 Vdout0_9ck121 = 1.1 time = 610
.meas tran vdout0_9ck121 FIND v(dout0_9) AT=610.025n

* CHECK dout0_10 Vdout0_10ck121 = 1.1 time = 610
.meas tran vdout0_10ck121 FIND v(dout0_10) AT=610.025n

* CHECK dout0_11 Vdout0_11ck121 = 1.1 time = 610
.meas tran vdout0_11ck121 FIND v(dout0_11) AT=610.025n

* CHECK dout0_12 Vdout0_12ck121 = 0 time = 610
.meas tran vdout0_12ck121 FIND v(dout0_12) AT=610.025n

* CHECK dout0_13 Vdout0_13ck121 = 0 time = 610
.meas tran vdout0_13ck121 FIND v(dout0_13) AT=610.025n

* CHECK dout0_14 Vdout0_14ck121 = 0 time = 610
.meas tran vdout0_14ck121 FIND v(dout0_14) AT=610.025n

* CHECK dout0_15 Vdout0_15ck121 = 0 time = 610
.meas tran vdout0_15ck121 FIND v(dout0_15) AT=610.025n

* CHECK dout0_16 Vdout0_16ck121 = 0 time = 610
.meas tran vdout0_16ck121 FIND v(dout0_16) AT=610.025n

* CHECK dout0_17 Vdout0_17ck121 = 0 time = 610
.meas tran vdout0_17ck121 FIND v(dout0_17) AT=610.025n

* CHECK dout0_18 Vdout0_18ck121 = 0 time = 610
.meas tran vdout0_18ck121 FIND v(dout0_18) AT=610.025n

* CHECK dout0_19 Vdout0_19ck121 = 1.1 time = 610
.meas tran vdout0_19ck121 FIND v(dout0_19) AT=610.025n

* CHECK dout0_20 Vdout0_20ck121 = 1.1 time = 610
.meas tran vdout0_20ck121 FIND v(dout0_20) AT=610.025n

* CHECK dout0_21 Vdout0_21ck121 = 1.1 time = 610
.meas tran vdout0_21ck121 FIND v(dout0_21) AT=610.025n

* CHECK dout0_22 Vdout0_22ck121 = 1.1 time = 610
.meas tran vdout0_22ck121 FIND v(dout0_22) AT=610.025n

* CHECK dout0_23 Vdout0_23ck121 = 1.1 time = 610
.meas tran vdout0_23ck121 FIND v(dout0_23) AT=610.025n

* CHECK dout0_24 Vdout0_24ck121 = 1.1 time = 610
.meas tran vdout0_24ck121 FIND v(dout0_24) AT=610.025n

* CHECK dout0_25 Vdout0_25ck121 = 0 time = 610
.meas tran vdout0_25ck121 FIND v(dout0_25) AT=610.025n

* CHECK dout0_26 Vdout0_26ck121 = 1.1 time = 610
.meas tran vdout0_26ck121 FIND v(dout0_26) AT=610.025n

* CHECK dout0_27 Vdout0_27ck121 = 1.1 time = 610
.meas tran vdout0_27ck121 FIND v(dout0_27) AT=610.025n

* CHECK dout0_28 Vdout0_28ck121 = 1.1 time = 610
.meas tran vdout0_28ck121 FIND v(dout0_28) AT=610.025n

* CHECK dout0_29 Vdout0_29ck121 = 0 time = 610
.meas tran vdout0_29ck121 FIND v(dout0_29) AT=610.025n

* CHECK dout0_30 Vdout0_30ck121 = 1.1 time = 610
.meas tran vdout0_30ck121 FIND v(dout0_30) AT=610.025n

* CHECK dout0_31 Vdout0_31ck121 = 1.1 time = 610
.meas tran vdout0_31ck121 FIND v(dout0_31) AT=610.025n

* CHECK dout0_0 Vdout0_0ck123 = 0 time = 620
.meas tran vdout0_0ck123 FIND v(dout0_0) AT=620.025n

* CHECK dout0_1 Vdout0_1ck123 = 1.1 time = 620
.meas tran vdout0_1ck123 FIND v(dout0_1) AT=620.025n

* CHECK dout0_2 Vdout0_2ck123 = 0 time = 620
.meas tran vdout0_2ck123 FIND v(dout0_2) AT=620.025n

* CHECK dout0_3 Vdout0_3ck123 = 1.1 time = 620
.meas tran vdout0_3ck123 FIND v(dout0_3) AT=620.025n

* CHECK dout0_4 Vdout0_4ck123 = 1.1 time = 620
.meas tran vdout0_4ck123 FIND v(dout0_4) AT=620.025n

* CHECK dout0_5 Vdout0_5ck123 = 0 time = 620
.meas tran vdout0_5ck123 FIND v(dout0_5) AT=620.025n

* CHECK dout0_6 Vdout0_6ck123 = 1.1 time = 620
.meas tran vdout0_6ck123 FIND v(dout0_6) AT=620.025n

* CHECK dout0_7 Vdout0_7ck123 = 1.1 time = 620
.meas tran vdout0_7ck123 FIND v(dout0_7) AT=620.025n

* CHECK dout0_8 Vdout0_8ck123 = 0 time = 620
.meas tran vdout0_8ck123 FIND v(dout0_8) AT=620.025n

* CHECK dout0_9 Vdout0_9ck123 = 0 time = 620
.meas tran vdout0_9ck123 FIND v(dout0_9) AT=620.025n

* CHECK dout0_10 Vdout0_10ck123 = 0 time = 620
.meas tran vdout0_10ck123 FIND v(dout0_10) AT=620.025n

* CHECK dout0_11 Vdout0_11ck123 = 0 time = 620
.meas tran vdout0_11ck123 FIND v(dout0_11) AT=620.025n

* CHECK dout0_12 Vdout0_12ck123 = 0 time = 620
.meas tran vdout0_12ck123 FIND v(dout0_12) AT=620.025n

* CHECK dout0_13 Vdout0_13ck123 = 0 time = 620
.meas tran vdout0_13ck123 FIND v(dout0_13) AT=620.025n

* CHECK dout0_14 Vdout0_14ck123 = 1.1 time = 620
.meas tran vdout0_14ck123 FIND v(dout0_14) AT=620.025n

* CHECK dout0_15 Vdout0_15ck123 = 1.1 time = 620
.meas tran vdout0_15ck123 FIND v(dout0_15) AT=620.025n

* CHECK dout0_16 Vdout0_16ck123 = 1.1 time = 620
.meas tran vdout0_16ck123 FIND v(dout0_16) AT=620.025n

* CHECK dout0_17 Vdout0_17ck123 = 0 time = 620
.meas tran vdout0_17ck123 FIND v(dout0_17) AT=620.025n

* CHECK dout0_18 Vdout0_18ck123 = 0 time = 620
.meas tran vdout0_18ck123 FIND v(dout0_18) AT=620.025n

* CHECK dout0_19 Vdout0_19ck123 = 0 time = 620
.meas tran vdout0_19ck123 FIND v(dout0_19) AT=620.025n

* CHECK dout0_20 Vdout0_20ck123 = 1.1 time = 620
.meas tran vdout0_20ck123 FIND v(dout0_20) AT=620.025n

* CHECK dout0_21 Vdout0_21ck123 = 0 time = 620
.meas tran vdout0_21ck123 FIND v(dout0_21) AT=620.025n

* CHECK dout0_22 Vdout0_22ck123 = 1.1 time = 620
.meas tran vdout0_22ck123 FIND v(dout0_22) AT=620.025n

* CHECK dout0_23 Vdout0_23ck123 = 0 time = 620
.meas tran vdout0_23ck123 FIND v(dout0_23) AT=620.025n

* CHECK dout0_24 Vdout0_24ck123 = 0 time = 620
.meas tran vdout0_24ck123 FIND v(dout0_24) AT=620.025n

* CHECK dout0_25 Vdout0_25ck123 = 0 time = 620
.meas tran vdout0_25ck123 FIND v(dout0_25) AT=620.025n

* CHECK dout0_26 Vdout0_26ck123 = 1.1 time = 620
.meas tran vdout0_26ck123 FIND v(dout0_26) AT=620.025n

* CHECK dout0_27 Vdout0_27ck123 = 1.1 time = 620
.meas tran vdout0_27ck123 FIND v(dout0_27) AT=620.025n

* CHECK dout0_28 Vdout0_28ck123 = 0 time = 620
.meas tran vdout0_28ck123 FIND v(dout0_28) AT=620.025n

* CHECK dout0_29 Vdout0_29ck123 = 1.1 time = 620
.meas tran vdout0_29ck123 FIND v(dout0_29) AT=620.025n

* CHECK dout0_30 Vdout0_30ck123 = 0 time = 620
.meas tran vdout0_30ck123 FIND v(dout0_30) AT=620.025n

* CHECK dout0_31 Vdout0_31ck123 = 0 time = 620
.meas tran vdout0_31ck123 FIND v(dout0_31) AT=620.025n

* CHECK dout0_0 Vdout0_0ck124 = 0 time = 625
.meas tran vdout0_0ck124 FIND v(dout0_0) AT=625.025n

* CHECK dout0_1 Vdout0_1ck124 = 1.1 time = 625
.meas tran vdout0_1ck124 FIND v(dout0_1) AT=625.025n

* CHECK dout0_2 Vdout0_2ck124 = 1.1 time = 625
.meas tran vdout0_2ck124 FIND v(dout0_2) AT=625.025n

* CHECK dout0_3 Vdout0_3ck124 = 1.1 time = 625
.meas tran vdout0_3ck124 FIND v(dout0_3) AT=625.025n

* CHECK dout0_4 Vdout0_4ck124 = 1.1 time = 625
.meas tran vdout0_4ck124 FIND v(dout0_4) AT=625.025n

* CHECK dout0_5 Vdout0_5ck124 = 1.1 time = 625
.meas tran vdout0_5ck124 FIND v(dout0_5) AT=625.025n

* CHECK dout0_6 Vdout0_6ck124 = 0 time = 625
.meas tran vdout0_6ck124 FIND v(dout0_6) AT=625.025n

* CHECK dout0_7 Vdout0_7ck124 = 0 time = 625
.meas tran vdout0_7ck124 FIND v(dout0_7) AT=625.025n

* CHECK dout0_8 Vdout0_8ck124 = 0 time = 625
.meas tran vdout0_8ck124 FIND v(dout0_8) AT=625.025n

* CHECK dout0_9 Vdout0_9ck124 = 1.1 time = 625
.meas tran vdout0_9ck124 FIND v(dout0_9) AT=625.025n

* CHECK dout0_10 Vdout0_10ck124 = 1.1 time = 625
.meas tran vdout0_10ck124 FIND v(dout0_10) AT=625.025n

* CHECK dout0_11 Vdout0_11ck124 = 0 time = 625
.meas tran vdout0_11ck124 FIND v(dout0_11) AT=625.025n

* CHECK dout0_12 Vdout0_12ck124 = 1.1 time = 625
.meas tran vdout0_12ck124 FIND v(dout0_12) AT=625.025n

* CHECK dout0_13 Vdout0_13ck124 = 1.1 time = 625
.meas tran vdout0_13ck124 FIND v(dout0_13) AT=625.025n

* CHECK dout0_14 Vdout0_14ck124 = 1.1 time = 625
.meas tran vdout0_14ck124 FIND v(dout0_14) AT=625.025n

* CHECK dout0_15 Vdout0_15ck124 = 1.1 time = 625
.meas tran vdout0_15ck124 FIND v(dout0_15) AT=625.025n

* CHECK dout0_16 Vdout0_16ck124 = 1.1 time = 625
.meas tran vdout0_16ck124 FIND v(dout0_16) AT=625.025n

* CHECK dout0_17 Vdout0_17ck124 = 1.1 time = 625
.meas tran vdout0_17ck124 FIND v(dout0_17) AT=625.025n

* CHECK dout0_18 Vdout0_18ck124 = 1.1 time = 625
.meas tran vdout0_18ck124 FIND v(dout0_18) AT=625.025n

* CHECK dout0_19 Vdout0_19ck124 = 1.1 time = 625
.meas tran vdout0_19ck124 FIND v(dout0_19) AT=625.025n

* CHECK dout0_20 Vdout0_20ck124 = 1.1 time = 625
.meas tran vdout0_20ck124 FIND v(dout0_20) AT=625.025n

* CHECK dout0_21 Vdout0_21ck124 = 1.1 time = 625
.meas tran vdout0_21ck124 FIND v(dout0_21) AT=625.025n

* CHECK dout0_22 Vdout0_22ck124 = 1.1 time = 625
.meas tran vdout0_22ck124 FIND v(dout0_22) AT=625.025n

* CHECK dout0_23 Vdout0_23ck124 = 0 time = 625
.meas tran vdout0_23ck124 FIND v(dout0_23) AT=625.025n

* CHECK dout0_24 Vdout0_24ck124 = 1.1 time = 625
.meas tran vdout0_24ck124 FIND v(dout0_24) AT=625.025n

* CHECK dout0_25 Vdout0_25ck124 = 1.1 time = 625
.meas tran vdout0_25ck124 FIND v(dout0_25) AT=625.025n

* CHECK dout0_26 Vdout0_26ck124 = 1.1 time = 625
.meas tran vdout0_26ck124 FIND v(dout0_26) AT=625.025n

* CHECK dout0_27 Vdout0_27ck124 = 1.1 time = 625
.meas tran vdout0_27ck124 FIND v(dout0_27) AT=625.025n

* CHECK dout0_28 Vdout0_28ck124 = 1.1 time = 625
.meas tran vdout0_28ck124 FIND v(dout0_28) AT=625.025n

* CHECK dout0_29 Vdout0_29ck124 = 1.1 time = 625
.meas tran vdout0_29ck124 FIND v(dout0_29) AT=625.025n

* CHECK dout0_30 Vdout0_30ck124 = 0 time = 625
.meas tran vdout0_30ck124 FIND v(dout0_30) AT=625.025n

* CHECK dout0_31 Vdout0_31ck124 = 0 time = 625
.meas tran vdout0_31ck124 FIND v(dout0_31) AT=625.025n

* CHECK dout0_0 Vdout0_0ck126 = 0 time = 635
.meas tran vdout0_0ck126 FIND v(dout0_0) AT=635.025n

* CHECK dout0_1 Vdout0_1ck126 = 1.1 time = 635
.meas tran vdout0_1ck126 FIND v(dout0_1) AT=635.025n

* CHECK dout0_2 Vdout0_2ck126 = 0 time = 635
.meas tran vdout0_2ck126 FIND v(dout0_2) AT=635.025n

* CHECK dout0_3 Vdout0_3ck126 = 1.1 time = 635
.meas tran vdout0_3ck126 FIND v(dout0_3) AT=635.025n

* CHECK dout0_4 Vdout0_4ck126 = 0 time = 635
.meas tran vdout0_4ck126 FIND v(dout0_4) AT=635.025n

* CHECK dout0_5 Vdout0_5ck126 = 0 time = 635
.meas tran vdout0_5ck126 FIND v(dout0_5) AT=635.025n

* CHECK dout0_6 Vdout0_6ck126 = 1.1 time = 635
.meas tran vdout0_6ck126 FIND v(dout0_6) AT=635.025n

* CHECK dout0_7 Vdout0_7ck126 = 0 time = 635
.meas tran vdout0_7ck126 FIND v(dout0_7) AT=635.025n

* CHECK dout0_8 Vdout0_8ck126 = 0 time = 635
.meas tran vdout0_8ck126 FIND v(dout0_8) AT=635.025n

* CHECK dout0_9 Vdout0_9ck126 = 0 time = 635
.meas tran vdout0_9ck126 FIND v(dout0_9) AT=635.025n

* CHECK dout0_10 Vdout0_10ck126 = 0 time = 635
.meas tran vdout0_10ck126 FIND v(dout0_10) AT=635.025n

* CHECK dout0_11 Vdout0_11ck126 = 0 time = 635
.meas tran vdout0_11ck126 FIND v(dout0_11) AT=635.025n

* CHECK dout0_12 Vdout0_12ck126 = 0 time = 635
.meas tran vdout0_12ck126 FIND v(dout0_12) AT=635.025n

* CHECK dout0_13 Vdout0_13ck126 = 0 time = 635
.meas tran vdout0_13ck126 FIND v(dout0_13) AT=635.025n

* CHECK dout0_14 Vdout0_14ck126 = 0 time = 635
.meas tran vdout0_14ck126 FIND v(dout0_14) AT=635.025n

* CHECK dout0_15 Vdout0_15ck126 = 0 time = 635
.meas tran vdout0_15ck126 FIND v(dout0_15) AT=635.025n

* CHECK dout0_16 Vdout0_16ck126 = 0 time = 635
.meas tran vdout0_16ck126 FIND v(dout0_16) AT=635.025n

* CHECK dout0_17 Vdout0_17ck126 = 1.1 time = 635
.meas tran vdout0_17ck126 FIND v(dout0_17) AT=635.025n

* CHECK dout0_18 Vdout0_18ck126 = 1.1 time = 635
.meas tran vdout0_18ck126 FIND v(dout0_18) AT=635.025n

* CHECK dout0_19 Vdout0_19ck126 = 1.1 time = 635
.meas tran vdout0_19ck126 FIND v(dout0_19) AT=635.025n

* CHECK dout0_20 Vdout0_20ck126 = 0 time = 635
.meas tran vdout0_20ck126 FIND v(dout0_20) AT=635.025n

* CHECK dout0_21 Vdout0_21ck126 = 0 time = 635
.meas tran vdout0_21ck126 FIND v(dout0_21) AT=635.025n

* CHECK dout0_22 Vdout0_22ck126 = 0 time = 635
.meas tran vdout0_22ck126 FIND v(dout0_22) AT=635.025n

* CHECK dout0_23 Vdout0_23ck126 = 1.1 time = 635
.meas tran vdout0_23ck126 FIND v(dout0_23) AT=635.025n

* CHECK dout0_24 Vdout0_24ck126 = 0 time = 635
.meas tran vdout0_24ck126 FIND v(dout0_24) AT=635.025n

* CHECK dout0_25 Vdout0_25ck126 = 1.1 time = 635
.meas tran vdout0_25ck126 FIND v(dout0_25) AT=635.025n

* CHECK dout0_26 Vdout0_26ck126 = 0 time = 635
.meas tran vdout0_26ck126 FIND v(dout0_26) AT=635.025n

* CHECK dout0_27 Vdout0_27ck126 = 0 time = 635
.meas tran vdout0_27ck126 FIND v(dout0_27) AT=635.025n

* CHECK dout0_28 Vdout0_28ck126 = 1.1 time = 635
.meas tran vdout0_28ck126 FIND v(dout0_28) AT=635.025n

* CHECK dout0_29 Vdout0_29ck126 = 1.1 time = 635
.meas tran vdout0_29ck126 FIND v(dout0_29) AT=635.025n

* CHECK dout0_30 Vdout0_30ck126 = 0 time = 635
.meas tran vdout0_30ck126 FIND v(dout0_30) AT=635.025n

* CHECK dout0_31 Vdout0_31ck126 = 1.1 time = 635
.meas tran vdout0_31ck126 FIND v(dout0_31) AT=635.025n

* CHECK dout0_0 Vdout0_0ck130 = 0 time = 655
.meas tran vdout0_0ck130 FIND v(dout0_0) AT=655.025n

* CHECK dout0_1 Vdout0_1ck130 = 1.1 time = 655
.meas tran vdout0_1ck130 FIND v(dout0_1) AT=655.025n

* CHECK dout0_2 Vdout0_2ck130 = 1.1 time = 655
.meas tran vdout0_2ck130 FIND v(dout0_2) AT=655.025n

* CHECK dout0_3 Vdout0_3ck130 = 1.1 time = 655
.meas tran vdout0_3ck130 FIND v(dout0_3) AT=655.025n

* CHECK dout0_4 Vdout0_4ck130 = 1.1 time = 655
.meas tran vdout0_4ck130 FIND v(dout0_4) AT=655.025n

* CHECK dout0_5 Vdout0_5ck130 = 1.1 time = 655
.meas tran vdout0_5ck130 FIND v(dout0_5) AT=655.025n

* CHECK dout0_6 Vdout0_6ck130 = 0 time = 655
.meas tran vdout0_6ck130 FIND v(dout0_6) AT=655.025n

* CHECK dout0_7 Vdout0_7ck130 = 0 time = 655
.meas tran vdout0_7ck130 FIND v(dout0_7) AT=655.025n

* CHECK dout0_8 Vdout0_8ck130 = 0 time = 655
.meas tran vdout0_8ck130 FIND v(dout0_8) AT=655.025n

* CHECK dout0_9 Vdout0_9ck130 = 1.1 time = 655
.meas tran vdout0_9ck130 FIND v(dout0_9) AT=655.025n

* CHECK dout0_10 Vdout0_10ck130 = 1.1 time = 655
.meas tran vdout0_10ck130 FIND v(dout0_10) AT=655.025n

* CHECK dout0_11 Vdout0_11ck130 = 0 time = 655
.meas tran vdout0_11ck130 FIND v(dout0_11) AT=655.025n

* CHECK dout0_12 Vdout0_12ck130 = 1.1 time = 655
.meas tran vdout0_12ck130 FIND v(dout0_12) AT=655.025n

* CHECK dout0_13 Vdout0_13ck130 = 1.1 time = 655
.meas tran vdout0_13ck130 FIND v(dout0_13) AT=655.025n

* CHECK dout0_14 Vdout0_14ck130 = 1.1 time = 655
.meas tran vdout0_14ck130 FIND v(dout0_14) AT=655.025n

* CHECK dout0_15 Vdout0_15ck130 = 1.1 time = 655
.meas tran vdout0_15ck130 FIND v(dout0_15) AT=655.025n

* CHECK dout0_16 Vdout0_16ck130 = 1.1 time = 655
.meas tran vdout0_16ck130 FIND v(dout0_16) AT=655.025n

* CHECK dout0_17 Vdout0_17ck130 = 1.1 time = 655
.meas tran vdout0_17ck130 FIND v(dout0_17) AT=655.025n

* CHECK dout0_18 Vdout0_18ck130 = 1.1 time = 655
.meas tran vdout0_18ck130 FIND v(dout0_18) AT=655.025n

* CHECK dout0_19 Vdout0_19ck130 = 1.1 time = 655
.meas tran vdout0_19ck130 FIND v(dout0_19) AT=655.025n

* CHECK dout0_20 Vdout0_20ck130 = 1.1 time = 655
.meas tran vdout0_20ck130 FIND v(dout0_20) AT=655.025n

* CHECK dout0_21 Vdout0_21ck130 = 1.1 time = 655
.meas tran vdout0_21ck130 FIND v(dout0_21) AT=655.025n

* CHECK dout0_22 Vdout0_22ck130 = 1.1 time = 655
.meas tran vdout0_22ck130 FIND v(dout0_22) AT=655.025n

* CHECK dout0_23 Vdout0_23ck130 = 0 time = 655
.meas tran vdout0_23ck130 FIND v(dout0_23) AT=655.025n

* CHECK dout0_24 Vdout0_24ck130 = 1.1 time = 655
.meas tran vdout0_24ck130 FIND v(dout0_24) AT=655.025n

* CHECK dout0_25 Vdout0_25ck130 = 1.1 time = 655
.meas tran vdout0_25ck130 FIND v(dout0_25) AT=655.025n

* CHECK dout0_26 Vdout0_26ck130 = 1.1 time = 655
.meas tran vdout0_26ck130 FIND v(dout0_26) AT=655.025n

* CHECK dout0_27 Vdout0_27ck130 = 1.1 time = 655
.meas tran vdout0_27ck130 FIND v(dout0_27) AT=655.025n

* CHECK dout0_28 Vdout0_28ck130 = 1.1 time = 655
.meas tran vdout0_28ck130 FIND v(dout0_28) AT=655.025n

* CHECK dout0_29 Vdout0_29ck130 = 1.1 time = 655
.meas tran vdout0_29ck130 FIND v(dout0_29) AT=655.025n

* CHECK dout0_30 Vdout0_30ck130 = 0 time = 655
.meas tran vdout0_30ck130 FIND v(dout0_30) AT=655.025n

* CHECK dout0_31 Vdout0_31ck130 = 0 time = 655
.meas tran vdout0_31ck130 FIND v(dout0_31) AT=655.025n

* CHECK dout0_0 Vdout0_0ck132 = 1.1 time = 665
.meas tran vdout0_0ck132 FIND v(dout0_0) AT=665.025n

* CHECK dout0_1 Vdout0_1ck132 = 0 time = 665
.meas tran vdout0_1ck132 FIND v(dout0_1) AT=665.025n

* CHECK dout0_2 Vdout0_2ck132 = 0 time = 665
.meas tran vdout0_2ck132 FIND v(dout0_2) AT=665.025n

* CHECK dout0_3 Vdout0_3ck132 = 1.1 time = 665
.meas tran vdout0_3ck132 FIND v(dout0_3) AT=665.025n

* CHECK dout0_4 Vdout0_4ck132 = 1.1 time = 665
.meas tran vdout0_4ck132 FIND v(dout0_4) AT=665.025n

* CHECK dout0_5 Vdout0_5ck132 = 1.1 time = 665
.meas tran vdout0_5ck132 FIND v(dout0_5) AT=665.025n

* CHECK dout0_6 Vdout0_6ck132 = 0 time = 665
.meas tran vdout0_6ck132 FIND v(dout0_6) AT=665.025n

* CHECK dout0_7 Vdout0_7ck132 = 1.1 time = 665
.meas tran vdout0_7ck132 FIND v(dout0_7) AT=665.025n

* CHECK dout0_8 Vdout0_8ck132 = 0 time = 665
.meas tran vdout0_8ck132 FIND v(dout0_8) AT=665.025n

* CHECK dout0_9 Vdout0_9ck132 = 0 time = 665
.meas tran vdout0_9ck132 FIND v(dout0_9) AT=665.025n

* CHECK dout0_10 Vdout0_10ck132 = 1.1 time = 665
.meas tran vdout0_10ck132 FIND v(dout0_10) AT=665.025n

* CHECK dout0_11 Vdout0_11ck132 = 0 time = 665
.meas tran vdout0_11ck132 FIND v(dout0_11) AT=665.025n

* CHECK dout0_12 Vdout0_12ck132 = 1.1 time = 665
.meas tran vdout0_12ck132 FIND v(dout0_12) AT=665.025n

* CHECK dout0_13 Vdout0_13ck132 = 1.1 time = 665
.meas tran vdout0_13ck132 FIND v(dout0_13) AT=665.025n

* CHECK dout0_14 Vdout0_14ck132 = 0 time = 665
.meas tran vdout0_14ck132 FIND v(dout0_14) AT=665.025n

* CHECK dout0_15 Vdout0_15ck132 = 0 time = 665
.meas tran vdout0_15ck132 FIND v(dout0_15) AT=665.025n

* CHECK dout0_16 Vdout0_16ck132 = 0 time = 665
.meas tran vdout0_16ck132 FIND v(dout0_16) AT=665.025n

* CHECK dout0_17 Vdout0_17ck132 = 1.1 time = 665
.meas tran vdout0_17ck132 FIND v(dout0_17) AT=665.025n

* CHECK dout0_18 Vdout0_18ck132 = 1.1 time = 665
.meas tran vdout0_18ck132 FIND v(dout0_18) AT=665.025n

* CHECK dout0_19 Vdout0_19ck132 = 0 time = 665
.meas tran vdout0_19ck132 FIND v(dout0_19) AT=665.025n

* CHECK dout0_20 Vdout0_20ck132 = 0 time = 665
.meas tran vdout0_20ck132 FIND v(dout0_20) AT=665.025n

* CHECK dout0_21 Vdout0_21ck132 = 0 time = 665
.meas tran vdout0_21ck132 FIND v(dout0_21) AT=665.025n

* CHECK dout0_22 Vdout0_22ck132 = 1.1 time = 665
.meas tran vdout0_22ck132 FIND v(dout0_22) AT=665.025n

* CHECK dout0_23 Vdout0_23ck132 = 0 time = 665
.meas tran vdout0_23ck132 FIND v(dout0_23) AT=665.025n

* CHECK dout0_24 Vdout0_24ck132 = 1.1 time = 665
.meas tran vdout0_24ck132 FIND v(dout0_24) AT=665.025n

* CHECK dout0_25 Vdout0_25ck132 = 1.1 time = 665
.meas tran vdout0_25ck132 FIND v(dout0_25) AT=665.025n

* CHECK dout0_26 Vdout0_26ck132 = 1.1 time = 665
.meas tran vdout0_26ck132 FIND v(dout0_26) AT=665.025n

* CHECK dout0_27 Vdout0_27ck132 = 0 time = 665
.meas tran vdout0_27ck132 FIND v(dout0_27) AT=665.025n

* CHECK dout0_28 Vdout0_28ck132 = 0 time = 665
.meas tran vdout0_28ck132 FIND v(dout0_28) AT=665.025n

* CHECK dout0_29 Vdout0_29ck132 = 1.1 time = 665
.meas tran vdout0_29ck132 FIND v(dout0_29) AT=665.025n

* CHECK dout0_30 Vdout0_30ck132 = 1.1 time = 665
.meas tran vdout0_30ck132 FIND v(dout0_30) AT=665.025n

* CHECK dout0_31 Vdout0_31ck132 = 1.1 time = 665
.meas tran vdout0_31ck132 FIND v(dout0_31) AT=665.025n

* CHECK dout0_0 Vdout0_0ck134 = 1.1 time = 675
.meas tran vdout0_0ck134 FIND v(dout0_0) AT=675.025n

* CHECK dout0_1 Vdout0_1ck134 = 0 time = 675
.meas tran vdout0_1ck134 FIND v(dout0_1) AT=675.025n

* CHECK dout0_2 Vdout0_2ck134 = 0 time = 675
.meas tran vdout0_2ck134 FIND v(dout0_2) AT=675.025n

* CHECK dout0_3 Vdout0_3ck134 = 1.1 time = 675
.meas tran vdout0_3ck134 FIND v(dout0_3) AT=675.025n

* CHECK dout0_4 Vdout0_4ck134 = 0 time = 675
.meas tran vdout0_4ck134 FIND v(dout0_4) AT=675.025n

* CHECK dout0_5 Vdout0_5ck134 = 1.1 time = 675
.meas tran vdout0_5ck134 FIND v(dout0_5) AT=675.025n

* CHECK dout0_6 Vdout0_6ck134 = 0 time = 675
.meas tran vdout0_6ck134 FIND v(dout0_6) AT=675.025n

* CHECK dout0_7 Vdout0_7ck134 = 1.1 time = 675
.meas tran vdout0_7ck134 FIND v(dout0_7) AT=675.025n

* CHECK dout0_8 Vdout0_8ck134 = 0 time = 675
.meas tran vdout0_8ck134 FIND v(dout0_8) AT=675.025n

* CHECK dout0_9 Vdout0_9ck134 = 1.1 time = 675
.meas tran vdout0_9ck134 FIND v(dout0_9) AT=675.025n

* CHECK dout0_10 Vdout0_10ck134 = 0 time = 675
.meas tran vdout0_10ck134 FIND v(dout0_10) AT=675.025n

* CHECK dout0_11 Vdout0_11ck134 = 1.1 time = 675
.meas tran vdout0_11ck134 FIND v(dout0_11) AT=675.025n

* CHECK dout0_12 Vdout0_12ck134 = 0 time = 675
.meas tran vdout0_12ck134 FIND v(dout0_12) AT=675.025n

* CHECK dout0_13 Vdout0_13ck134 = 0 time = 675
.meas tran vdout0_13ck134 FIND v(dout0_13) AT=675.025n

* CHECK dout0_14 Vdout0_14ck134 = 0 time = 675
.meas tran vdout0_14ck134 FIND v(dout0_14) AT=675.025n

* CHECK dout0_15 Vdout0_15ck134 = 0 time = 675
.meas tran vdout0_15ck134 FIND v(dout0_15) AT=675.025n

* CHECK dout0_16 Vdout0_16ck134 = 1.1 time = 675
.meas tran vdout0_16ck134 FIND v(dout0_16) AT=675.025n

* CHECK dout0_17 Vdout0_17ck134 = 1.1 time = 675
.meas tran vdout0_17ck134 FIND v(dout0_17) AT=675.025n

* CHECK dout0_18 Vdout0_18ck134 = 0 time = 675
.meas tran vdout0_18ck134 FIND v(dout0_18) AT=675.025n

* CHECK dout0_19 Vdout0_19ck134 = 0 time = 675
.meas tran vdout0_19ck134 FIND v(dout0_19) AT=675.025n

* CHECK dout0_20 Vdout0_20ck134 = 1.1 time = 675
.meas tran vdout0_20ck134 FIND v(dout0_20) AT=675.025n

* CHECK dout0_21 Vdout0_21ck134 = 1.1 time = 675
.meas tran vdout0_21ck134 FIND v(dout0_21) AT=675.025n

* CHECK dout0_22 Vdout0_22ck134 = 1.1 time = 675
.meas tran vdout0_22ck134 FIND v(dout0_22) AT=675.025n

* CHECK dout0_23 Vdout0_23ck134 = 0 time = 675
.meas tran vdout0_23ck134 FIND v(dout0_23) AT=675.025n

* CHECK dout0_24 Vdout0_24ck134 = 0 time = 675
.meas tran vdout0_24ck134 FIND v(dout0_24) AT=675.025n

* CHECK dout0_25 Vdout0_25ck134 = 0 time = 675
.meas tran vdout0_25ck134 FIND v(dout0_25) AT=675.025n

* CHECK dout0_26 Vdout0_26ck134 = 0 time = 675
.meas tran vdout0_26ck134 FIND v(dout0_26) AT=675.025n

* CHECK dout0_27 Vdout0_27ck134 = 1.1 time = 675
.meas tran vdout0_27ck134 FIND v(dout0_27) AT=675.025n

* CHECK dout0_28 Vdout0_28ck134 = 1.1 time = 675
.meas tran vdout0_28ck134 FIND v(dout0_28) AT=675.025n

* CHECK dout0_29 Vdout0_29ck134 = 0 time = 675
.meas tran vdout0_29ck134 FIND v(dout0_29) AT=675.025n

* CHECK dout0_30 Vdout0_30ck134 = 1.1 time = 675
.meas tran vdout0_30ck134 FIND v(dout0_30) AT=675.025n

* CHECK dout0_31 Vdout0_31ck134 = 1.1 time = 675
.meas tran vdout0_31ck134 FIND v(dout0_31) AT=675.025n

* CHECK dout0_0 Vdout0_0ck137 = 1.1 time = 690
.meas tran vdout0_0ck137 FIND v(dout0_0) AT=690.025n

* CHECK dout0_1 Vdout0_1ck137 = 0 time = 690
.meas tran vdout0_1ck137 FIND v(dout0_1) AT=690.025n

* CHECK dout0_2 Vdout0_2ck137 = 1.1 time = 690
.meas tran vdout0_2ck137 FIND v(dout0_2) AT=690.025n

* CHECK dout0_3 Vdout0_3ck137 = 1.1 time = 690
.meas tran vdout0_3ck137 FIND v(dout0_3) AT=690.025n

* CHECK dout0_4 Vdout0_4ck137 = 1.1 time = 690
.meas tran vdout0_4ck137 FIND v(dout0_4) AT=690.025n

* CHECK dout0_5 Vdout0_5ck137 = 0 time = 690
.meas tran vdout0_5ck137 FIND v(dout0_5) AT=690.025n

* CHECK dout0_6 Vdout0_6ck137 = 1.1 time = 690
.meas tran vdout0_6ck137 FIND v(dout0_6) AT=690.025n

* CHECK dout0_7 Vdout0_7ck137 = 1.1 time = 690
.meas tran vdout0_7ck137 FIND v(dout0_7) AT=690.025n

* CHECK dout0_8 Vdout0_8ck137 = 0 time = 690
.meas tran vdout0_8ck137 FIND v(dout0_8) AT=690.025n

* CHECK dout0_9 Vdout0_9ck137 = 0 time = 690
.meas tran vdout0_9ck137 FIND v(dout0_9) AT=690.025n

* CHECK dout0_10 Vdout0_10ck137 = 0 time = 690
.meas tran vdout0_10ck137 FIND v(dout0_10) AT=690.025n

* CHECK dout0_11 Vdout0_11ck137 = 1.1 time = 690
.meas tran vdout0_11ck137 FIND v(dout0_11) AT=690.025n

* CHECK dout0_12 Vdout0_12ck137 = 1.1 time = 690
.meas tran vdout0_12ck137 FIND v(dout0_12) AT=690.025n

* CHECK dout0_13 Vdout0_13ck137 = 1.1 time = 690
.meas tran vdout0_13ck137 FIND v(dout0_13) AT=690.025n

* CHECK dout0_14 Vdout0_14ck137 = 1.1 time = 690
.meas tran vdout0_14ck137 FIND v(dout0_14) AT=690.025n

* CHECK dout0_15 Vdout0_15ck137 = 1.1 time = 690
.meas tran vdout0_15ck137 FIND v(dout0_15) AT=690.025n

* CHECK dout0_16 Vdout0_16ck137 = 0 time = 690
.meas tran vdout0_16ck137 FIND v(dout0_16) AT=690.025n

* CHECK dout0_17 Vdout0_17ck137 = 0 time = 690
.meas tran vdout0_17ck137 FIND v(dout0_17) AT=690.025n

* CHECK dout0_18 Vdout0_18ck137 = 0 time = 690
.meas tran vdout0_18ck137 FIND v(dout0_18) AT=690.025n

* CHECK dout0_19 Vdout0_19ck137 = 1.1 time = 690
.meas tran vdout0_19ck137 FIND v(dout0_19) AT=690.025n

* CHECK dout0_20 Vdout0_20ck137 = 0 time = 690
.meas tran vdout0_20ck137 FIND v(dout0_20) AT=690.025n

* CHECK dout0_21 Vdout0_21ck137 = 1.1 time = 690
.meas tran vdout0_21ck137 FIND v(dout0_21) AT=690.025n

* CHECK dout0_22 Vdout0_22ck137 = 0 time = 690
.meas tran vdout0_22ck137 FIND v(dout0_22) AT=690.025n

* CHECK dout0_23 Vdout0_23ck137 = 1.1 time = 690
.meas tran vdout0_23ck137 FIND v(dout0_23) AT=690.025n

* CHECK dout0_24 Vdout0_24ck137 = 0 time = 690
.meas tran vdout0_24ck137 FIND v(dout0_24) AT=690.025n

* CHECK dout0_25 Vdout0_25ck137 = 1.1 time = 690
.meas tran vdout0_25ck137 FIND v(dout0_25) AT=690.025n

* CHECK dout0_26 Vdout0_26ck137 = 0 time = 690
.meas tran vdout0_26ck137 FIND v(dout0_26) AT=690.025n

* CHECK dout0_27 Vdout0_27ck137 = 1.1 time = 690
.meas tran vdout0_27ck137 FIND v(dout0_27) AT=690.025n

* CHECK dout0_28 Vdout0_28ck137 = 1.1 time = 690
.meas tran vdout0_28ck137 FIND v(dout0_28) AT=690.025n

* CHECK dout0_29 Vdout0_29ck137 = 0 time = 690
.meas tran vdout0_29ck137 FIND v(dout0_29) AT=690.025n

* CHECK dout0_30 Vdout0_30ck137 = 1.1 time = 690
.meas tran vdout0_30ck137 FIND v(dout0_30) AT=690.025n

* CHECK dout0_31 Vdout0_31ck137 = 1.1 time = 690
.meas tran vdout0_31ck137 FIND v(dout0_31) AT=690.025n

* CHECK dout0_0 Vdout0_0ck139 = 0 time = 700
.meas tran vdout0_0ck139 FIND v(dout0_0) AT=700.025n

* CHECK dout0_1 Vdout0_1ck139 = 1.1 time = 700
.meas tran vdout0_1ck139 FIND v(dout0_1) AT=700.025n

* CHECK dout0_2 Vdout0_2ck139 = 0 time = 700
.meas tran vdout0_2ck139 FIND v(dout0_2) AT=700.025n

* CHECK dout0_3 Vdout0_3ck139 = 0 time = 700
.meas tran vdout0_3ck139 FIND v(dout0_3) AT=700.025n

* CHECK dout0_4 Vdout0_4ck139 = 1.1 time = 700
.meas tran vdout0_4ck139 FIND v(dout0_4) AT=700.025n

* CHECK dout0_5 Vdout0_5ck139 = 0 time = 700
.meas tran vdout0_5ck139 FIND v(dout0_5) AT=700.025n

* CHECK dout0_6 Vdout0_6ck139 = 0 time = 700
.meas tran vdout0_6ck139 FIND v(dout0_6) AT=700.025n

* CHECK dout0_7 Vdout0_7ck139 = 1.1 time = 700
.meas tran vdout0_7ck139 FIND v(dout0_7) AT=700.025n

* CHECK dout0_8 Vdout0_8ck139 = 1.1 time = 700
.meas tran vdout0_8ck139 FIND v(dout0_8) AT=700.025n

* CHECK dout0_9 Vdout0_9ck139 = 1.1 time = 700
.meas tran vdout0_9ck139 FIND v(dout0_9) AT=700.025n

* CHECK dout0_10 Vdout0_10ck139 = 1.1 time = 700
.meas tran vdout0_10ck139 FIND v(dout0_10) AT=700.025n

* CHECK dout0_11 Vdout0_11ck139 = 0 time = 700
.meas tran vdout0_11ck139 FIND v(dout0_11) AT=700.025n

* CHECK dout0_12 Vdout0_12ck139 = 1.1 time = 700
.meas tran vdout0_12ck139 FIND v(dout0_12) AT=700.025n

* CHECK dout0_13 Vdout0_13ck139 = 0 time = 700
.meas tran vdout0_13ck139 FIND v(dout0_13) AT=700.025n

* CHECK dout0_14 Vdout0_14ck139 = 1.1 time = 700
.meas tran vdout0_14ck139 FIND v(dout0_14) AT=700.025n

* CHECK dout0_15 Vdout0_15ck139 = 0 time = 700
.meas tran vdout0_15ck139 FIND v(dout0_15) AT=700.025n

* CHECK dout0_16 Vdout0_16ck139 = 1.1 time = 700
.meas tran vdout0_16ck139 FIND v(dout0_16) AT=700.025n

* CHECK dout0_17 Vdout0_17ck139 = 0 time = 700
.meas tran vdout0_17ck139 FIND v(dout0_17) AT=700.025n

* CHECK dout0_18 Vdout0_18ck139 = 1.1 time = 700
.meas tran vdout0_18ck139 FIND v(dout0_18) AT=700.025n

* CHECK dout0_19 Vdout0_19ck139 = 0 time = 700
.meas tran vdout0_19ck139 FIND v(dout0_19) AT=700.025n

* CHECK dout0_20 Vdout0_20ck139 = 1.1 time = 700
.meas tran vdout0_20ck139 FIND v(dout0_20) AT=700.025n

* CHECK dout0_21 Vdout0_21ck139 = 0 time = 700
.meas tran vdout0_21ck139 FIND v(dout0_21) AT=700.025n

* CHECK dout0_22 Vdout0_22ck139 = 1.1 time = 700
.meas tran vdout0_22ck139 FIND v(dout0_22) AT=700.025n

* CHECK dout0_23 Vdout0_23ck139 = 0 time = 700
.meas tran vdout0_23ck139 FIND v(dout0_23) AT=700.025n

* CHECK dout0_24 Vdout0_24ck139 = 1.1 time = 700
.meas tran vdout0_24ck139 FIND v(dout0_24) AT=700.025n

* CHECK dout0_25 Vdout0_25ck139 = 1.1 time = 700
.meas tran vdout0_25ck139 FIND v(dout0_25) AT=700.025n

* CHECK dout0_26 Vdout0_26ck139 = 1.1 time = 700
.meas tran vdout0_26ck139 FIND v(dout0_26) AT=700.025n

* CHECK dout0_27 Vdout0_27ck139 = 0 time = 700
.meas tran vdout0_27ck139 FIND v(dout0_27) AT=700.025n

* CHECK dout0_28 Vdout0_28ck139 = 1.1 time = 700
.meas tran vdout0_28ck139 FIND v(dout0_28) AT=700.025n

* CHECK dout0_29 Vdout0_29ck139 = 0 time = 700
.meas tran vdout0_29ck139 FIND v(dout0_29) AT=700.025n

* CHECK dout0_30 Vdout0_30ck139 = 0 time = 700
.meas tran vdout0_30ck139 FIND v(dout0_30) AT=700.025n

* CHECK dout0_31 Vdout0_31ck139 = 1.1 time = 700
.meas tran vdout0_31ck139 FIND v(dout0_31) AT=700.025n

* CHECK dout0_0 Vdout0_0ck142 = 1.1 time = 715
.meas tran vdout0_0ck142 FIND v(dout0_0) AT=715.025n

* CHECK dout0_1 Vdout0_1ck142 = 0 time = 715
.meas tran vdout0_1ck142 FIND v(dout0_1) AT=715.025n

* CHECK dout0_2 Vdout0_2ck142 = 0 time = 715
.meas tran vdout0_2ck142 FIND v(dout0_2) AT=715.025n

* CHECK dout0_3 Vdout0_3ck142 = 1.1 time = 715
.meas tran vdout0_3ck142 FIND v(dout0_3) AT=715.025n

* CHECK dout0_4 Vdout0_4ck142 = 0 time = 715
.meas tran vdout0_4ck142 FIND v(dout0_4) AT=715.025n

* CHECK dout0_5 Vdout0_5ck142 = 1.1 time = 715
.meas tran vdout0_5ck142 FIND v(dout0_5) AT=715.025n

* CHECK dout0_6 Vdout0_6ck142 = 0 time = 715
.meas tran vdout0_6ck142 FIND v(dout0_6) AT=715.025n

* CHECK dout0_7 Vdout0_7ck142 = 1.1 time = 715
.meas tran vdout0_7ck142 FIND v(dout0_7) AT=715.025n

* CHECK dout0_8 Vdout0_8ck142 = 0 time = 715
.meas tran vdout0_8ck142 FIND v(dout0_8) AT=715.025n

* CHECK dout0_9 Vdout0_9ck142 = 1.1 time = 715
.meas tran vdout0_9ck142 FIND v(dout0_9) AT=715.025n

* CHECK dout0_10 Vdout0_10ck142 = 0 time = 715
.meas tran vdout0_10ck142 FIND v(dout0_10) AT=715.025n

* CHECK dout0_11 Vdout0_11ck142 = 1.1 time = 715
.meas tran vdout0_11ck142 FIND v(dout0_11) AT=715.025n

* CHECK dout0_12 Vdout0_12ck142 = 0 time = 715
.meas tran vdout0_12ck142 FIND v(dout0_12) AT=715.025n

* CHECK dout0_13 Vdout0_13ck142 = 0 time = 715
.meas tran vdout0_13ck142 FIND v(dout0_13) AT=715.025n

* CHECK dout0_14 Vdout0_14ck142 = 0 time = 715
.meas tran vdout0_14ck142 FIND v(dout0_14) AT=715.025n

* CHECK dout0_15 Vdout0_15ck142 = 0 time = 715
.meas tran vdout0_15ck142 FIND v(dout0_15) AT=715.025n

* CHECK dout0_16 Vdout0_16ck142 = 1.1 time = 715
.meas tran vdout0_16ck142 FIND v(dout0_16) AT=715.025n

* CHECK dout0_17 Vdout0_17ck142 = 1.1 time = 715
.meas tran vdout0_17ck142 FIND v(dout0_17) AT=715.025n

* CHECK dout0_18 Vdout0_18ck142 = 0 time = 715
.meas tran vdout0_18ck142 FIND v(dout0_18) AT=715.025n

* CHECK dout0_19 Vdout0_19ck142 = 0 time = 715
.meas tran vdout0_19ck142 FIND v(dout0_19) AT=715.025n

* CHECK dout0_20 Vdout0_20ck142 = 1.1 time = 715
.meas tran vdout0_20ck142 FIND v(dout0_20) AT=715.025n

* CHECK dout0_21 Vdout0_21ck142 = 1.1 time = 715
.meas tran vdout0_21ck142 FIND v(dout0_21) AT=715.025n

* CHECK dout0_22 Vdout0_22ck142 = 1.1 time = 715
.meas tran vdout0_22ck142 FIND v(dout0_22) AT=715.025n

* CHECK dout0_23 Vdout0_23ck142 = 0 time = 715
.meas tran vdout0_23ck142 FIND v(dout0_23) AT=715.025n

* CHECK dout0_24 Vdout0_24ck142 = 0 time = 715
.meas tran vdout0_24ck142 FIND v(dout0_24) AT=715.025n

* CHECK dout0_25 Vdout0_25ck142 = 0 time = 715
.meas tran vdout0_25ck142 FIND v(dout0_25) AT=715.025n

* CHECK dout0_26 Vdout0_26ck142 = 0 time = 715
.meas tran vdout0_26ck142 FIND v(dout0_26) AT=715.025n

* CHECK dout0_27 Vdout0_27ck142 = 1.1 time = 715
.meas tran vdout0_27ck142 FIND v(dout0_27) AT=715.025n

* CHECK dout0_28 Vdout0_28ck142 = 1.1 time = 715
.meas tran vdout0_28ck142 FIND v(dout0_28) AT=715.025n

* CHECK dout0_29 Vdout0_29ck142 = 0 time = 715
.meas tran vdout0_29ck142 FIND v(dout0_29) AT=715.025n

* CHECK dout0_30 Vdout0_30ck142 = 1.1 time = 715
.meas tran vdout0_30ck142 FIND v(dout0_30) AT=715.025n

* CHECK dout0_31 Vdout0_31ck142 = 1.1 time = 715
.meas tran vdout0_31ck142 FIND v(dout0_31) AT=715.025n

* CHECK dout0_0 Vdout0_0ck143 = 0 time = 720
.meas tran vdout0_0ck143 FIND v(dout0_0) AT=720.025n

* CHECK dout0_1 Vdout0_1ck143 = 0 time = 720
.meas tran vdout0_1ck143 FIND v(dout0_1) AT=720.025n

* CHECK dout0_2 Vdout0_2ck143 = 1.1 time = 720
.meas tran vdout0_2ck143 FIND v(dout0_2) AT=720.025n

* CHECK dout0_3 Vdout0_3ck143 = 0 time = 720
.meas tran vdout0_3ck143 FIND v(dout0_3) AT=720.025n

* CHECK dout0_4 Vdout0_4ck143 = 1.1 time = 720
.meas tran vdout0_4ck143 FIND v(dout0_4) AT=720.025n

* CHECK dout0_5 Vdout0_5ck143 = 1.1 time = 720
.meas tran vdout0_5ck143 FIND v(dout0_5) AT=720.025n

* CHECK dout0_6 Vdout0_6ck143 = 0 time = 720
.meas tran vdout0_6ck143 FIND v(dout0_6) AT=720.025n

* CHECK dout0_7 Vdout0_7ck143 = 1.1 time = 720
.meas tran vdout0_7ck143 FIND v(dout0_7) AT=720.025n

* CHECK dout0_8 Vdout0_8ck143 = 1.1 time = 720
.meas tran vdout0_8ck143 FIND v(dout0_8) AT=720.025n

* CHECK dout0_9 Vdout0_9ck143 = 1.1 time = 720
.meas tran vdout0_9ck143 FIND v(dout0_9) AT=720.025n

* CHECK dout0_10 Vdout0_10ck143 = 1.1 time = 720
.meas tran vdout0_10ck143 FIND v(dout0_10) AT=720.025n

* CHECK dout0_11 Vdout0_11ck143 = 0 time = 720
.meas tran vdout0_11ck143 FIND v(dout0_11) AT=720.025n

* CHECK dout0_12 Vdout0_12ck143 = 1.1 time = 720
.meas tran vdout0_12ck143 FIND v(dout0_12) AT=720.025n

* CHECK dout0_13 Vdout0_13ck143 = 1.1 time = 720
.meas tran vdout0_13ck143 FIND v(dout0_13) AT=720.025n

* CHECK dout0_14 Vdout0_14ck143 = 1.1 time = 720
.meas tran vdout0_14ck143 FIND v(dout0_14) AT=720.025n

* CHECK dout0_15 Vdout0_15ck143 = 0 time = 720
.meas tran vdout0_15ck143 FIND v(dout0_15) AT=720.025n

* CHECK dout0_16 Vdout0_16ck143 = 1.1 time = 720
.meas tran vdout0_16ck143 FIND v(dout0_16) AT=720.025n

* CHECK dout0_17 Vdout0_17ck143 = 0 time = 720
.meas tran vdout0_17ck143 FIND v(dout0_17) AT=720.025n

* CHECK dout0_18 Vdout0_18ck143 = 0 time = 720
.meas tran vdout0_18ck143 FIND v(dout0_18) AT=720.025n

* CHECK dout0_19 Vdout0_19ck143 = 1.1 time = 720
.meas tran vdout0_19ck143 FIND v(dout0_19) AT=720.025n

* CHECK dout0_20 Vdout0_20ck143 = 1.1 time = 720
.meas tran vdout0_20ck143 FIND v(dout0_20) AT=720.025n

* CHECK dout0_21 Vdout0_21ck143 = 1.1 time = 720
.meas tran vdout0_21ck143 FIND v(dout0_21) AT=720.025n

* CHECK dout0_22 Vdout0_22ck143 = 1.1 time = 720
.meas tran vdout0_22ck143 FIND v(dout0_22) AT=720.025n

* CHECK dout0_23 Vdout0_23ck143 = 1.1 time = 720
.meas tran vdout0_23ck143 FIND v(dout0_23) AT=720.025n

* CHECK dout0_24 Vdout0_24ck143 = 1.1 time = 720
.meas tran vdout0_24ck143 FIND v(dout0_24) AT=720.025n

* CHECK dout0_25 Vdout0_25ck143 = 1.1 time = 720
.meas tran vdout0_25ck143 FIND v(dout0_25) AT=720.025n

* CHECK dout0_26 Vdout0_26ck143 = 0 time = 720
.meas tran vdout0_26ck143 FIND v(dout0_26) AT=720.025n

* CHECK dout0_27 Vdout0_27ck143 = 0 time = 720
.meas tran vdout0_27ck143 FIND v(dout0_27) AT=720.025n

* CHECK dout0_28 Vdout0_28ck143 = 1.1 time = 720
.meas tran vdout0_28ck143 FIND v(dout0_28) AT=720.025n

* CHECK dout0_29 Vdout0_29ck143 = 0 time = 720
.meas tran vdout0_29ck143 FIND v(dout0_29) AT=720.025n

* CHECK dout0_30 Vdout0_30ck143 = 1.1 time = 720
.meas tran vdout0_30ck143 FIND v(dout0_30) AT=720.025n

* CHECK dout0_31 Vdout0_31ck143 = 1.1 time = 720
.meas tran vdout0_31ck143 FIND v(dout0_31) AT=720.025n

* CHECK dout0_0 Vdout0_0ck146 = 0 time = 735
.meas tran vdout0_0ck146 FIND v(dout0_0) AT=735.025n

* CHECK dout0_1 Vdout0_1ck146 = 0 time = 735
.meas tran vdout0_1ck146 FIND v(dout0_1) AT=735.025n

* CHECK dout0_2 Vdout0_2ck146 = 1.1 time = 735
.meas tran vdout0_2ck146 FIND v(dout0_2) AT=735.025n

* CHECK dout0_3 Vdout0_3ck146 = 0 time = 735
.meas tran vdout0_3ck146 FIND v(dout0_3) AT=735.025n

* CHECK dout0_4 Vdout0_4ck146 = 1.1 time = 735
.meas tran vdout0_4ck146 FIND v(dout0_4) AT=735.025n

* CHECK dout0_5 Vdout0_5ck146 = 1.1 time = 735
.meas tran vdout0_5ck146 FIND v(dout0_5) AT=735.025n

* CHECK dout0_6 Vdout0_6ck146 = 0 time = 735
.meas tran vdout0_6ck146 FIND v(dout0_6) AT=735.025n

* CHECK dout0_7 Vdout0_7ck146 = 1.1 time = 735
.meas tran vdout0_7ck146 FIND v(dout0_7) AT=735.025n

* CHECK dout0_8 Vdout0_8ck146 = 1.1 time = 735
.meas tran vdout0_8ck146 FIND v(dout0_8) AT=735.025n

* CHECK dout0_9 Vdout0_9ck146 = 1.1 time = 735
.meas tran vdout0_9ck146 FIND v(dout0_9) AT=735.025n

* CHECK dout0_10 Vdout0_10ck146 = 1.1 time = 735
.meas tran vdout0_10ck146 FIND v(dout0_10) AT=735.025n

* CHECK dout0_11 Vdout0_11ck146 = 0 time = 735
.meas tran vdout0_11ck146 FIND v(dout0_11) AT=735.025n

* CHECK dout0_12 Vdout0_12ck146 = 1.1 time = 735
.meas tran vdout0_12ck146 FIND v(dout0_12) AT=735.025n

* CHECK dout0_13 Vdout0_13ck146 = 1.1 time = 735
.meas tran vdout0_13ck146 FIND v(dout0_13) AT=735.025n

* CHECK dout0_14 Vdout0_14ck146 = 1.1 time = 735
.meas tran vdout0_14ck146 FIND v(dout0_14) AT=735.025n

* CHECK dout0_15 Vdout0_15ck146 = 0 time = 735
.meas tran vdout0_15ck146 FIND v(dout0_15) AT=735.025n

* CHECK dout0_16 Vdout0_16ck146 = 1.1 time = 735
.meas tran vdout0_16ck146 FIND v(dout0_16) AT=735.025n

* CHECK dout0_17 Vdout0_17ck146 = 0 time = 735
.meas tran vdout0_17ck146 FIND v(dout0_17) AT=735.025n

* CHECK dout0_18 Vdout0_18ck146 = 0 time = 735
.meas tran vdout0_18ck146 FIND v(dout0_18) AT=735.025n

* CHECK dout0_19 Vdout0_19ck146 = 1.1 time = 735
.meas tran vdout0_19ck146 FIND v(dout0_19) AT=735.025n

* CHECK dout0_20 Vdout0_20ck146 = 1.1 time = 735
.meas tran vdout0_20ck146 FIND v(dout0_20) AT=735.025n

* CHECK dout0_21 Vdout0_21ck146 = 1.1 time = 735
.meas tran vdout0_21ck146 FIND v(dout0_21) AT=735.025n

* CHECK dout0_22 Vdout0_22ck146 = 1.1 time = 735
.meas tran vdout0_22ck146 FIND v(dout0_22) AT=735.025n

* CHECK dout0_23 Vdout0_23ck146 = 1.1 time = 735
.meas tran vdout0_23ck146 FIND v(dout0_23) AT=735.025n

* CHECK dout0_24 Vdout0_24ck146 = 1.1 time = 735
.meas tran vdout0_24ck146 FIND v(dout0_24) AT=735.025n

* CHECK dout0_25 Vdout0_25ck146 = 1.1 time = 735
.meas tran vdout0_25ck146 FIND v(dout0_25) AT=735.025n

* CHECK dout0_26 Vdout0_26ck146 = 0 time = 735
.meas tran vdout0_26ck146 FIND v(dout0_26) AT=735.025n

* CHECK dout0_27 Vdout0_27ck146 = 0 time = 735
.meas tran vdout0_27ck146 FIND v(dout0_27) AT=735.025n

* CHECK dout0_28 Vdout0_28ck146 = 1.1 time = 735
.meas tran vdout0_28ck146 FIND v(dout0_28) AT=735.025n

* CHECK dout0_29 Vdout0_29ck146 = 0 time = 735
.meas tran vdout0_29ck146 FIND v(dout0_29) AT=735.025n

* CHECK dout0_30 Vdout0_30ck146 = 1.1 time = 735
.meas tran vdout0_30ck146 FIND v(dout0_30) AT=735.025n

* CHECK dout0_31 Vdout0_31ck146 = 1.1 time = 735
.meas tran vdout0_31ck146 FIND v(dout0_31) AT=735.025n

* CHECK dout0_0 Vdout0_0ck148 = 0 time = 745
.meas tran vdout0_0ck148 FIND v(dout0_0) AT=745.025n

* CHECK dout0_1 Vdout0_1ck148 = 1.1 time = 745
.meas tran vdout0_1ck148 FIND v(dout0_1) AT=745.025n

* CHECK dout0_2 Vdout0_2ck148 = 0 time = 745
.meas tran vdout0_2ck148 FIND v(dout0_2) AT=745.025n

* CHECK dout0_3 Vdout0_3ck148 = 0 time = 745
.meas tran vdout0_3ck148 FIND v(dout0_3) AT=745.025n

* CHECK dout0_4 Vdout0_4ck148 = 1.1 time = 745
.meas tran vdout0_4ck148 FIND v(dout0_4) AT=745.025n

* CHECK dout0_5 Vdout0_5ck148 = 0 time = 745
.meas tran vdout0_5ck148 FIND v(dout0_5) AT=745.025n

* CHECK dout0_6 Vdout0_6ck148 = 0 time = 745
.meas tran vdout0_6ck148 FIND v(dout0_6) AT=745.025n

* CHECK dout0_7 Vdout0_7ck148 = 1.1 time = 745
.meas tran vdout0_7ck148 FIND v(dout0_7) AT=745.025n

* CHECK dout0_8 Vdout0_8ck148 = 1.1 time = 745
.meas tran vdout0_8ck148 FIND v(dout0_8) AT=745.025n

* CHECK dout0_9 Vdout0_9ck148 = 1.1 time = 745
.meas tran vdout0_9ck148 FIND v(dout0_9) AT=745.025n

* CHECK dout0_10 Vdout0_10ck148 = 1.1 time = 745
.meas tran vdout0_10ck148 FIND v(dout0_10) AT=745.025n

* CHECK dout0_11 Vdout0_11ck148 = 0 time = 745
.meas tran vdout0_11ck148 FIND v(dout0_11) AT=745.025n

* CHECK dout0_12 Vdout0_12ck148 = 1.1 time = 745
.meas tran vdout0_12ck148 FIND v(dout0_12) AT=745.025n

* CHECK dout0_13 Vdout0_13ck148 = 0 time = 745
.meas tran vdout0_13ck148 FIND v(dout0_13) AT=745.025n

* CHECK dout0_14 Vdout0_14ck148 = 1.1 time = 745
.meas tran vdout0_14ck148 FIND v(dout0_14) AT=745.025n

* CHECK dout0_15 Vdout0_15ck148 = 0 time = 745
.meas tran vdout0_15ck148 FIND v(dout0_15) AT=745.025n

* CHECK dout0_16 Vdout0_16ck148 = 1.1 time = 745
.meas tran vdout0_16ck148 FIND v(dout0_16) AT=745.025n

* CHECK dout0_17 Vdout0_17ck148 = 0 time = 745
.meas tran vdout0_17ck148 FIND v(dout0_17) AT=745.025n

* CHECK dout0_18 Vdout0_18ck148 = 1.1 time = 745
.meas tran vdout0_18ck148 FIND v(dout0_18) AT=745.025n

* CHECK dout0_19 Vdout0_19ck148 = 0 time = 745
.meas tran vdout0_19ck148 FIND v(dout0_19) AT=745.025n

* CHECK dout0_20 Vdout0_20ck148 = 1.1 time = 745
.meas tran vdout0_20ck148 FIND v(dout0_20) AT=745.025n

* CHECK dout0_21 Vdout0_21ck148 = 0 time = 745
.meas tran vdout0_21ck148 FIND v(dout0_21) AT=745.025n

* CHECK dout0_22 Vdout0_22ck148 = 1.1 time = 745
.meas tran vdout0_22ck148 FIND v(dout0_22) AT=745.025n

* CHECK dout0_23 Vdout0_23ck148 = 0 time = 745
.meas tran vdout0_23ck148 FIND v(dout0_23) AT=745.025n

* CHECK dout0_24 Vdout0_24ck148 = 1.1 time = 745
.meas tran vdout0_24ck148 FIND v(dout0_24) AT=745.025n

* CHECK dout0_25 Vdout0_25ck148 = 1.1 time = 745
.meas tran vdout0_25ck148 FIND v(dout0_25) AT=745.025n

* CHECK dout0_26 Vdout0_26ck148 = 1.1 time = 745
.meas tran vdout0_26ck148 FIND v(dout0_26) AT=745.025n

* CHECK dout0_27 Vdout0_27ck148 = 0 time = 745
.meas tran vdout0_27ck148 FIND v(dout0_27) AT=745.025n

* CHECK dout0_28 Vdout0_28ck148 = 1.1 time = 745
.meas tran vdout0_28ck148 FIND v(dout0_28) AT=745.025n

* CHECK dout0_29 Vdout0_29ck148 = 0 time = 745
.meas tran vdout0_29ck148 FIND v(dout0_29) AT=745.025n

* CHECK dout0_30 Vdout0_30ck148 = 0 time = 745
.meas tran vdout0_30ck148 FIND v(dout0_30) AT=745.025n

* CHECK dout0_31 Vdout0_31ck148 = 1.1 time = 745
.meas tran vdout0_31ck148 FIND v(dout0_31) AT=745.025n

* CHECK dout0_0 Vdout0_0ck149 = 0 time = 750
.meas tran vdout0_0ck149 FIND v(dout0_0) AT=750.025n

* CHECK dout0_1 Vdout0_1ck149 = 1.1 time = 750
.meas tran vdout0_1ck149 FIND v(dout0_1) AT=750.025n

* CHECK dout0_2 Vdout0_2ck149 = 1.1 time = 750
.meas tran vdout0_2ck149 FIND v(dout0_2) AT=750.025n

* CHECK dout0_3 Vdout0_3ck149 = 1.1 time = 750
.meas tran vdout0_3ck149 FIND v(dout0_3) AT=750.025n

* CHECK dout0_4 Vdout0_4ck149 = 1.1 time = 750
.meas tran vdout0_4ck149 FIND v(dout0_4) AT=750.025n

* CHECK dout0_5 Vdout0_5ck149 = 1.1 time = 750
.meas tran vdout0_5ck149 FIND v(dout0_5) AT=750.025n

* CHECK dout0_6 Vdout0_6ck149 = 0 time = 750
.meas tran vdout0_6ck149 FIND v(dout0_6) AT=750.025n

* CHECK dout0_7 Vdout0_7ck149 = 0 time = 750
.meas tran vdout0_7ck149 FIND v(dout0_7) AT=750.025n

* CHECK dout0_8 Vdout0_8ck149 = 0 time = 750
.meas tran vdout0_8ck149 FIND v(dout0_8) AT=750.025n

* CHECK dout0_9 Vdout0_9ck149 = 1.1 time = 750
.meas tran vdout0_9ck149 FIND v(dout0_9) AT=750.025n

* CHECK dout0_10 Vdout0_10ck149 = 1.1 time = 750
.meas tran vdout0_10ck149 FIND v(dout0_10) AT=750.025n

* CHECK dout0_11 Vdout0_11ck149 = 0 time = 750
.meas tran vdout0_11ck149 FIND v(dout0_11) AT=750.025n

* CHECK dout0_12 Vdout0_12ck149 = 1.1 time = 750
.meas tran vdout0_12ck149 FIND v(dout0_12) AT=750.025n

* CHECK dout0_13 Vdout0_13ck149 = 1.1 time = 750
.meas tran vdout0_13ck149 FIND v(dout0_13) AT=750.025n

* CHECK dout0_14 Vdout0_14ck149 = 1.1 time = 750
.meas tran vdout0_14ck149 FIND v(dout0_14) AT=750.025n

* CHECK dout0_15 Vdout0_15ck149 = 1.1 time = 750
.meas tran vdout0_15ck149 FIND v(dout0_15) AT=750.025n

* CHECK dout0_16 Vdout0_16ck149 = 1.1 time = 750
.meas tran vdout0_16ck149 FIND v(dout0_16) AT=750.025n

* CHECK dout0_17 Vdout0_17ck149 = 1.1 time = 750
.meas tran vdout0_17ck149 FIND v(dout0_17) AT=750.025n

* CHECK dout0_18 Vdout0_18ck149 = 1.1 time = 750
.meas tran vdout0_18ck149 FIND v(dout0_18) AT=750.025n

* CHECK dout0_19 Vdout0_19ck149 = 1.1 time = 750
.meas tran vdout0_19ck149 FIND v(dout0_19) AT=750.025n

* CHECK dout0_20 Vdout0_20ck149 = 1.1 time = 750
.meas tran vdout0_20ck149 FIND v(dout0_20) AT=750.025n

* CHECK dout0_21 Vdout0_21ck149 = 1.1 time = 750
.meas tran vdout0_21ck149 FIND v(dout0_21) AT=750.025n

* CHECK dout0_22 Vdout0_22ck149 = 1.1 time = 750
.meas tran vdout0_22ck149 FIND v(dout0_22) AT=750.025n

* CHECK dout0_23 Vdout0_23ck149 = 0 time = 750
.meas tran vdout0_23ck149 FIND v(dout0_23) AT=750.025n

* CHECK dout0_24 Vdout0_24ck149 = 1.1 time = 750
.meas tran vdout0_24ck149 FIND v(dout0_24) AT=750.025n

* CHECK dout0_25 Vdout0_25ck149 = 1.1 time = 750
.meas tran vdout0_25ck149 FIND v(dout0_25) AT=750.025n

* CHECK dout0_26 Vdout0_26ck149 = 1.1 time = 750
.meas tran vdout0_26ck149 FIND v(dout0_26) AT=750.025n

* CHECK dout0_27 Vdout0_27ck149 = 1.1 time = 750
.meas tran vdout0_27ck149 FIND v(dout0_27) AT=750.025n

* CHECK dout0_28 Vdout0_28ck149 = 1.1 time = 750
.meas tran vdout0_28ck149 FIND v(dout0_28) AT=750.025n

* CHECK dout0_29 Vdout0_29ck149 = 1.1 time = 750
.meas tran vdout0_29ck149 FIND v(dout0_29) AT=750.025n

* CHECK dout0_30 Vdout0_30ck149 = 0 time = 750
.meas tran vdout0_30ck149 FIND v(dout0_30) AT=750.025n

* CHECK dout0_31 Vdout0_31ck149 = 0 time = 750
.meas tran vdout0_31ck149 FIND v(dout0_31) AT=750.025n

* CHECK dout0_0 Vdout0_0ck152 = 0 time = 765
.meas tran vdout0_0ck152 FIND v(dout0_0) AT=765.025n

* CHECK dout0_1 Vdout0_1ck152 = 0 time = 765
.meas tran vdout0_1ck152 FIND v(dout0_1) AT=765.025n

* CHECK dout0_2 Vdout0_2ck152 = 0 time = 765
.meas tran vdout0_2ck152 FIND v(dout0_2) AT=765.025n

* CHECK dout0_3 Vdout0_3ck152 = 1.1 time = 765
.meas tran vdout0_3ck152 FIND v(dout0_3) AT=765.025n

* CHECK dout0_4 Vdout0_4ck152 = 1.1 time = 765
.meas tran vdout0_4ck152 FIND v(dout0_4) AT=765.025n

* CHECK dout0_5 Vdout0_5ck152 = 1.1 time = 765
.meas tran vdout0_5ck152 FIND v(dout0_5) AT=765.025n

* CHECK dout0_6 Vdout0_6ck152 = 1.1 time = 765
.meas tran vdout0_6ck152 FIND v(dout0_6) AT=765.025n

* CHECK dout0_7 Vdout0_7ck152 = 1.1 time = 765
.meas tran vdout0_7ck152 FIND v(dout0_7) AT=765.025n

* CHECK dout0_8 Vdout0_8ck152 = 1.1 time = 765
.meas tran vdout0_8ck152 FIND v(dout0_8) AT=765.025n

* CHECK dout0_9 Vdout0_9ck152 = 0 time = 765
.meas tran vdout0_9ck152 FIND v(dout0_9) AT=765.025n

* CHECK dout0_10 Vdout0_10ck152 = 1.1 time = 765
.meas tran vdout0_10ck152 FIND v(dout0_10) AT=765.025n

* CHECK dout0_11 Vdout0_11ck152 = 0 time = 765
.meas tran vdout0_11ck152 FIND v(dout0_11) AT=765.025n

* CHECK dout0_12 Vdout0_12ck152 = 0 time = 765
.meas tran vdout0_12ck152 FIND v(dout0_12) AT=765.025n

* CHECK dout0_13 Vdout0_13ck152 = 0 time = 765
.meas tran vdout0_13ck152 FIND v(dout0_13) AT=765.025n

* CHECK dout0_14 Vdout0_14ck152 = 0 time = 765
.meas tran vdout0_14ck152 FIND v(dout0_14) AT=765.025n

* CHECK dout0_15 Vdout0_15ck152 = 0 time = 765
.meas tran vdout0_15ck152 FIND v(dout0_15) AT=765.025n

* CHECK dout0_16 Vdout0_16ck152 = 0 time = 765
.meas tran vdout0_16ck152 FIND v(dout0_16) AT=765.025n

* CHECK dout0_17 Vdout0_17ck152 = 1.1 time = 765
.meas tran vdout0_17ck152 FIND v(dout0_17) AT=765.025n

* CHECK dout0_18 Vdout0_18ck152 = 0 time = 765
.meas tran vdout0_18ck152 FIND v(dout0_18) AT=765.025n

* CHECK dout0_19 Vdout0_19ck152 = 0 time = 765
.meas tran vdout0_19ck152 FIND v(dout0_19) AT=765.025n

* CHECK dout0_20 Vdout0_20ck152 = 1.1 time = 765
.meas tran vdout0_20ck152 FIND v(dout0_20) AT=765.025n

* CHECK dout0_21 Vdout0_21ck152 = 1.1 time = 765
.meas tran vdout0_21ck152 FIND v(dout0_21) AT=765.025n

* CHECK dout0_22 Vdout0_22ck152 = 0 time = 765
.meas tran vdout0_22ck152 FIND v(dout0_22) AT=765.025n

* CHECK dout0_23 Vdout0_23ck152 = 1.1 time = 765
.meas tran vdout0_23ck152 FIND v(dout0_23) AT=765.025n

* CHECK dout0_24 Vdout0_24ck152 = 1.1 time = 765
.meas tran vdout0_24ck152 FIND v(dout0_24) AT=765.025n

* CHECK dout0_25 Vdout0_25ck152 = 1.1 time = 765
.meas tran vdout0_25ck152 FIND v(dout0_25) AT=765.025n

* CHECK dout0_26 Vdout0_26ck152 = 0 time = 765
.meas tran vdout0_26ck152 FIND v(dout0_26) AT=765.025n

* CHECK dout0_27 Vdout0_27ck152 = 0 time = 765
.meas tran vdout0_27ck152 FIND v(dout0_27) AT=765.025n

* CHECK dout0_28 Vdout0_28ck152 = 0 time = 765
.meas tran vdout0_28ck152 FIND v(dout0_28) AT=765.025n

* CHECK dout0_29 Vdout0_29ck152 = 1.1 time = 765
.meas tran vdout0_29ck152 FIND v(dout0_29) AT=765.025n

* CHECK dout0_30 Vdout0_30ck152 = 0 time = 765
.meas tran vdout0_30ck152 FIND v(dout0_30) AT=765.025n

* CHECK dout0_31 Vdout0_31ck152 = 0 time = 765
.meas tran vdout0_31ck152 FIND v(dout0_31) AT=765.025n

* CHECK dout0_0 Vdout0_0ck157 = 1.1 time = 790
.meas tran vdout0_0ck157 FIND v(dout0_0) AT=790.025n

* CHECK dout0_1 Vdout0_1ck157 = 1.1 time = 790
.meas tran vdout0_1ck157 FIND v(dout0_1) AT=790.025n

* CHECK dout0_2 Vdout0_2ck157 = 0 time = 790
.meas tran vdout0_2ck157 FIND v(dout0_2) AT=790.025n

* CHECK dout0_3 Vdout0_3ck157 = 1.1 time = 790
.meas tran vdout0_3ck157 FIND v(dout0_3) AT=790.025n

* CHECK dout0_4 Vdout0_4ck157 = 1.1 time = 790
.meas tran vdout0_4ck157 FIND v(dout0_4) AT=790.025n

* CHECK dout0_5 Vdout0_5ck157 = 0 time = 790
.meas tran vdout0_5ck157 FIND v(dout0_5) AT=790.025n

* CHECK dout0_6 Vdout0_6ck157 = 0 time = 790
.meas tran vdout0_6ck157 FIND v(dout0_6) AT=790.025n

* CHECK dout0_7 Vdout0_7ck157 = 1.1 time = 790
.meas tran vdout0_7ck157 FIND v(dout0_7) AT=790.025n

* CHECK dout0_8 Vdout0_8ck157 = 1.1 time = 790
.meas tran vdout0_8ck157 FIND v(dout0_8) AT=790.025n

* CHECK dout0_9 Vdout0_9ck157 = 0 time = 790
.meas tran vdout0_9ck157 FIND v(dout0_9) AT=790.025n

* CHECK dout0_10 Vdout0_10ck157 = 0 time = 790
.meas tran vdout0_10ck157 FIND v(dout0_10) AT=790.025n

* CHECK dout0_11 Vdout0_11ck157 = 0 time = 790
.meas tran vdout0_11ck157 FIND v(dout0_11) AT=790.025n

* CHECK dout0_12 Vdout0_12ck157 = 0 time = 790
.meas tran vdout0_12ck157 FIND v(dout0_12) AT=790.025n

* CHECK dout0_13 Vdout0_13ck157 = 0 time = 790
.meas tran vdout0_13ck157 FIND v(dout0_13) AT=790.025n

* CHECK dout0_14 Vdout0_14ck157 = 0 time = 790
.meas tran vdout0_14ck157 FIND v(dout0_14) AT=790.025n

* CHECK dout0_15 Vdout0_15ck157 = 0 time = 790
.meas tran vdout0_15ck157 FIND v(dout0_15) AT=790.025n

* CHECK dout0_16 Vdout0_16ck157 = 1.1 time = 790
.meas tran vdout0_16ck157 FIND v(dout0_16) AT=790.025n

* CHECK dout0_17 Vdout0_17ck157 = 0 time = 790
.meas tran vdout0_17ck157 FIND v(dout0_17) AT=790.025n

* CHECK dout0_18 Vdout0_18ck157 = 1.1 time = 790
.meas tran vdout0_18ck157 FIND v(dout0_18) AT=790.025n

* CHECK dout0_19 Vdout0_19ck157 = 0 time = 790
.meas tran vdout0_19ck157 FIND v(dout0_19) AT=790.025n

* CHECK dout0_20 Vdout0_20ck157 = 1.1 time = 790
.meas tran vdout0_20ck157 FIND v(dout0_20) AT=790.025n

* CHECK dout0_21 Vdout0_21ck157 = 0 time = 790
.meas tran vdout0_21ck157 FIND v(dout0_21) AT=790.025n

* CHECK dout0_22 Vdout0_22ck157 = 1.1 time = 790
.meas tran vdout0_22ck157 FIND v(dout0_22) AT=790.025n

* CHECK dout0_23 Vdout0_23ck157 = 1.1 time = 790
.meas tran vdout0_23ck157 FIND v(dout0_23) AT=790.025n

* CHECK dout0_24 Vdout0_24ck157 = 0 time = 790
.meas tran vdout0_24ck157 FIND v(dout0_24) AT=790.025n

* CHECK dout0_25 Vdout0_25ck157 = 1.1 time = 790
.meas tran vdout0_25ck157 FIND v(dout0_25) AT=790.025n

* CHECK dout0_26 Vdout0_26ck157 = 1.1 time = 790
.meas tran vdout0_26ck157 FIND v(dout0_26) AT=790.025n

* CHECK dout0_27 Vdout0_27ck157 = 1.1 time = 790
.meas tran vdout0_27ck157 FIND v(dout0_27) AT=790.025n

* CHECK dout0_28 Vdout0_28ck157 = 1.1 time = 790
.meas tran vdout0_28ck157 FIND v(dout0_28) AT=790.025n

* CHECK dout0_29 Vdout0_29ck157 = 0 time = 790
.meas tran vdout0_29ck157 FIND v(dout0_29) AT=790.025n

* CHECK dout0_30 Vdout0_30ck157 = 0 time = 790
.meas tran vdout0_30ck157 FIND v(dout0_30) AT=790.025n

* CHECK dout0_31 Vdout0_31ck157 = 0 time = 790
.meas tran vdout0_31ck157 FIND v(dout0_31) AT=790.025n

* CHECK dout0_0 Vdout0_0ck160 = 0 time = 805
.meas tran vdout0_0ck160 FIND v(dout0_0) AT=805.025n

* CHECK dout0_1 Vdout0_1ck160 = 1.1 time = 805
.meas tran vdout0_1ck160 FIND v(dout0_1) AT=805.025n

* CHECK dout0_2 Vdout0_2ck160 = 0 time = 805
.meas tran vdout0_2ck160 FIND v(dout0_2) AT=805.025n

* CHECK dout0_3 Vdout0_3ck160 = 0 time = 805
.meas tran vdout0_3ck160 FIND v(dout0_3) AT=805.025n

* CHECK dout0_4 Vdout0_4ck160 = 1.1 time = 805
.meas tran vdout0_4ck160 FIND v(dout0_4) AT=805.025n

* CHECK dout0_5 Vdout0_5ck160 = 0 time = 805
.meas tran vdout0_5ck160 FIND v(dout0_5) AT=805.025n

* CHECK dout0_6 Vdout0_6ck160 = 0 time = 805
.meas tran vdout0_6ck160 FIND v(dout0_6) AT=805.025n

* CHECK dout0_7 Vdout0_7ck160 = 1.1 time = 805
.meas tran vdout0_7ck160 FIND v(dout0_7) AT=805.025n

* CHECK dout0_8 Vdout0_8ck160 = 1.1 time = 805
.meas tran vdout0_8ck160 FIND v(dout0_8) AT=805.025n

* CHECK dout0_9 Vdout0_9ck160 = 1.1 time = 805
.meas tran vdout0_9ck160 FIND v(dout0_9) AT=805.025n

* CHECK dout0_10 Vdout0_10ck160 = 1.1 time = 805
.meas tran vdout0_10ck160 FIND v(dout0_10) AT=805.025n

* CHECK dout0_11 Vdout0_11ck160 = 0 time = 805
.meas tran vdout0_11ck160 FIND v(dout0_11) AT=805.025n

* CHECK dout0_12 Vdout0_12ck160 = 1.1 time = 805
.meas tran vdout0_12ck160 FIND v(dout0_12) AT=805.025n

* CHECK dout0_13 Vdout0_13ck160 = 0 time = 805
.meas tran vdout0_13ck160 FIND v(dout0_13) AT=805.025n

* CHECK dout0_14 Vdout0_14ck160 = 1.1 time = 805
.meas tran vdout0_14ck160 FIND v(dout0_14) AT=805.025n

* CHECK dout0_15 Vdout0_15ck160 = 0 time = 805
.meas tran vdout0_15ck160 FIND v(dout0_15) AT=805.025n

* CHECK dout0_16 Vdout0_16ck160 = 1.1 time = 805
.meas tran vdout0_16ck160 FIND v(dout0_16) AT=805.025n

* CHECK dout0_17 Vdout0_17ck160 = 0 time = 805
.meas tran vdout0_17ck160 FIND v(dout0_17) AT=805.025n

* CHECK dout0_18 Vdout0_18ck160 = 1.1 time = 805
.meas tran vdout0_18ck160 FIND v(dout0_18) AT=805.025n

* CHECK dout0_19 Vdout0_19ck160 = 0 time = 805
.meas tran vdout0_19ck160 FIND v(dout0_19) AT=805.025n

* CHECK dout0_20 Vdout0_20ck160 = 1.1 time = 805
.meas tran vdout0_20ck160 FIND v(dout0_20) AT=805.025n

* CHECK dout0_21 Vdout0_21ck160 = 0 time = 805
.meas tran vdout0_21ck160 FIND v(dout0_21) AT=805.025n

* CHECK dout0_22 Vdout0_22ck160 = 1.1 time = 805
.meas tran vdout0_22ck160 FIND v(dout0_22) AT=805.025n

* CHECK dout0_23 Vdout0_23ck160 = 0 time = 805
.meas tran vdout0_23ck160 FIND v(dout0_23) AT=805.025n

* CHECK dout0_24 Vdout0_24ck160 = 1.1 time = 805
.meas tran vdout0_24ck160 FIND v(dout0_24) AT=805.025n

* CHECK dout0_25 Vdout0_25ck160 = 1.1 time = 805
.meas tran vdout0_25ck160 FIND v(dout0_25) AT=805.025n

* CHECK dout0_26 Vdout0_26ck160 = 1.1 time = 805
.meas tran vdout0_26ck160 FIND v(dout0_26) AT=805.025n

* CHECK dout0_27 Vdout0_27ck160 = 0 time = 805
.meas tran vdout0_27ck160 FIND v(dout0_27) AT=805.025n

* CHECK dout0_28 Vdout0_28ck160 = 1.1 time = 805
.meas tran vdout0_28ck160 FIND v(dout0_28) AT=805.025n

* CHECK dout0_29 Vdout0_29ck160 = 0 time = 805
.meas tran vdout0_29ck160 FIND v(dout0_29) AT=805.025n

* CHECK dout0_30 Vdout0_30ck160 = 0 time = 805
.meas tran vdout0_30ck160 FIND v(dout0_30) AT=805.025n

* CHECK dout0_31 Vdout0_31ck160 = 1.1 time = 805
.meas tran vdout0_31ck160 FIND v(dout0_31) AT=805.025n

* CHECK dout0_0 Vdout0_0ck161 = 0 time = 810
.meas tran vdout0_0ck161 FIND v(dout0_0) AT=810.025n

* CHECK dout0_1 Vdout0_1ck161 = 0 time = 810
.meas tran vdout0_1ck161 FIND v(dout0_1) AT=810.025n

* CHECK dout0_2 Vdout0_2ck161 = 0 time = 810
.meas tran vdout0_2ck161 FIND v(dout0_2) AT=810.025n

* CHECK dout0_3 Vdout0_3ck161 = 1.1 time = 810
.meas tran vdout0_3ck161 FIND v(dout0_3) AT=810.025n

* CHECK dout0_4 Vdout0_4ck161 = 1.1 time = 810
.meas tran vdout0_4ck161 FIND v(dout0_4) AT=810.025n

* CHECK dout0_5 Vdout0_5ck161 = 1.1 time = 810
.meas tran vdout0_5ck161 FIND v(dout0_5) AT=810.025n

* CHECK dout0_6 Vdout0_6ck161 = 1.1 time = 810
.meas tran vdout0_6ck161 FIND v(dout0_6) AT=810.025n

* CHECK dout0_7 Vdout0_7ck161 = 1.1 time = 810
.meas tran vdout0_7ck161 FIND v(dout0_7) AT=810.025n

* CHECK dout0_8 Vdout0_8ck161 = 1.1 time = 810
.meas tran vdout0_8ck161 FIND v(dout0_8) AT=810.025n

* CHECK dout0_9 Vdout0_9ck161 = 0 time = 810
.meas tran vdout0_9ck161 FIND v(dout0_9) AT=810.025n

* CHECK dout0_10 Vdout0_10ck161 = 1.1 time = 810
.meas tran vdout0_10ck161 FIND v(dout0_10) AT=810.025n

* CHECK dout0_11 Vdout0_11ck161 = 0 time = 810
.meas tran vdout0_11ck161 FIND v(dout0_11) AT=810.025n

* CHECK dout0_12 Vdout0_12ck161 = 0 time = 810
.meas tran vdout0_12ck161 FIND v(dout0_12) AT=810.025n

* CHECK dout0_13 Vdout0_13ck161 = 0 time = 810
.meas tran vdout0_13ck161 FIND v(dout0_13) AT=810.025n

* CHECK dout0_14 Vdout0_14ck161 = 0 time = 810
.meas tran vdout0_14ck161 FIND v(dout0_14) AT=810.025n

* CHECK dout0_15 Vdout0_15ck161 = 0 time = 810
.meas tran vdout0_15ck161 FIND v(dout0_15) AT=810.025n

* CHECK dout0_16 Vdout0_16ck161 = 0 time = 810
.meas tran vdout0_16ck161 FIND v(dout0_16) AT=810.025n

* CHECK dout0_17 Vdout0_17ck161 = 1.1 time = 810
.meas tran vdout0_17ck161 FIND v(dout0_17) AT=810.025n

* CHECK dout0_18 Vdout0_18ck161 = 0 time = 810
.meas tran vdout0_18ck161 FIND v(dout0_18) AT=810.025n

* CHECK dout0_19 Vdout0_19ck161 = 0 time = 810
.meas tran vdout0_19ck161 FIND v(dout0_19) AT=810.025n

* CHECK dout0_20 Vdout0_20ck161 = 1.1 time = 810
.meas tran vdout0_20ck161 FIND v(dout0_20) AT=810.025n

* CHECK dout0_21 Vdout0_21ck161 = 1.1 time = 810
.meas tran vdout0_21ck161 FIND v(dout0_21) AT=810.025n

* CHECK dout0_22 Vdout0_22ck161 = 0 time = 810
.meas tran vdout0_22ck161 FIND v(dout0_22) AT=810.025n

* CHECK dout0_23 Vdout0_23ck161 = 1.1 time = 810
.meas tran vdout0_23ck161 FIND v(dout0_23) AT=810.025n

* CHECK dout0_24 Vdout0_24ck161 = 1.1 time = 810
.meas tran vdout0_24ck161 FIND v(dout0_24) AT=810.025n

* CHECK dout0_25 Vdout0_25ck161 = 1.1 time = 810
.meas tran vdout0_25ck161 FIND v(dout0_25) AT=810.025n

* CHECK dout0_26 Vdout0_26ck161 = 0 time = 810
.meas tran vdout0_26ck161 FIND v(dout0_26) AT=810.025n

* CHECK dout0_27 Vdout0_27ck161 = 0 time = 810
.meas tran vdout0_27ck161 FIND v(dout0_27) AT=810.025n

* CHECK dout0_28 Vdout0_28ck161 = 0 time = 810
.meas tran vdout0_28ck161 FIND v(dout0_28) AT=810.025n

* CHECK dout0_29 Vdout0_29ck161 = 1.1 time = 810
.meas tran vdout0_29ck161 FIND v(dout0_29) AT=810.025n

* CHECK dout0_30 Vdout0_30ck161 = 0 time = 810
.meas tran vdout0_30ck161 FIND v(dout0_30) AT=810.025n

* CHECK dout0_31 Vdout0_31ck161 = 0 time = 810
.meas tran vdout0_31ck161 FIND v(dout0_31) AT=810.025n

* CHECK dout0_0 Vdout0_0ck162 = 1.1 time = 815
.meas tran vdout0_0ck162 FIND v(dout0_0) AT=815.025n

* CHECK dout0_1 Vdout0_1ck162 = 1.1 time = 815
.meas tran vdout0_1ck162 FIND v(dout0_1) AT=815.025n

* CHECK dout0_2 Vdout0_2ck162 = 0 time = 815
.meas tran vdout0_2ck162 FIND v(dout0_2) AT=815.025n

* CHECK dout0_3 Vdout0_3ck162 = 0 time = 815
.meas tran vdout0_3ck162 FIND v(dout0_3) AT=815.025n

* CHECK dout0_4 Vdout0_4ck162 = 0 time = 815
.meas tran vdout0_4ck162 FIND v(dout0_4) AT=815.025n

* CHECK dout0_5 Vdout0_5ck162 = 0 time = 815
.meas tran vdout0_5ck162 FIND v(dout0_5) AT=815.025n

* CHECK dout0_6 Vdout0_6ck162 = 0 time = 815
.meas tran vdout0_6ck162 FIND v(dout0_6) AT=815.025n

* CHECK dout0_7 Vdout0_7ck162 = 0 time = 815
.meas tran vdout0_7ck162 FIND v(dout0_7) AT=815.025n

* CHECK dout0_8 Vdout0_8ck162 = 1.1 time = 815
.meas tran vdout0_8ck162 FIND v(dout0_8) AT=815.025n

* CHECK dout0_9 Vdout0_9ck162 = 0 time = 815
.meas tran vdout0_9ck162 FIND v(dout0_9) AT=815.025n

* CHECK dout0_10 Vdout0_10ck162 = 0 time = 815
.meas tran vdout0_10ck162 FIND v(dout0_10) AT=815.025n

* CHECK dout0_11 Vdout0_11ck162 = 0 time = 815
.meas tran vdout0_11ck162 FIND v(dout0_11) AT=815.025n

* CHECK dout0_12 Vdout0_12ck162 = 1.1 time = 815
.meas tran vdout0_12ck162 FIND v(dout0_12) AT=815.025n

* CHECK dout0_13 Vdout0_13ck162 = 0 time = 815
.meas tran vdout0_13ck162 FIND v(dout0_13) AT=815.025n

* CHECK dout0_14 Vdout0_14ck162 = 1.1 time = 815
.meas tran vdout0_14ck162 FIND v(dout0_14) AT=815.025n

* CHECK dout0_15 Vdout0_15ck162 = 1.1 time = 815
.meas tran vdout0_15ck162 FIND v(dout0_15) AT=815.025n

* CHECK dout0_16 Vdout0_16ck162 = 0 time = 815
.meas tran vdout0_16ck162 FIND v(dout0_16) AT=815.025n

* CHECK dout0_17 Vdout0_17ck162 = 1.1 time = 815
.meas tran vdout0_17ck162 FIND v(dout0_17) AT=815.025n

* CHECK dout0_18 Vdout0_18ck162 = 0 time = 815
.meas tran vdout0_18ck162 FIND v(dout0_18) AT=815.025n

* CHECK dout0_19 Vdout0_19ck162 = 1.1 time = 815
.meas tran vdout0_19ck162 FIND v(dout0_19) AT=815.025n

* CHECK dout0_20 Vdout0_20ck162 = 0 time = 815
.meas tran vdout0_20ck162 FIND v(dout0_20) AT=815.025n

* CHECK dout0_21 Vdout0_21ck162 = 0 time = 815
.meas tran vdout0_21ck162 FIND v(dout0_21) AT=815.025n

* CHECK dout0_22 Vdout0_22ck162 = 0 time = 815
.meas tran vdout0_22ck162 FIND v(dout0_22) AT=815.025n

* CHECK dout0_23 Vdout0_23ck162 = 1.1 time = 815
.meas tran vdout0_23ck162 FIND v(dout0_23) AT=815.025n

* CHECK dout0_24 Vdout0_24ck162 = 1.1 time = 815
.meas tran vdout0_24ck162 FIND v(dout0_24) AT=815.025n

* CHECK dout0_25 Vdout0_25ck162 = 0 time = 815
.meas tran vdout0_25ck162 FIND v(dout0_25) AT=815.025n

* CHECK dout0_26 Vdout0_26ck162 = 0 time = 815
.meas tran vdout0_26ck162 FIND v(dout0_26) AT=815.025n

* CHECK dout0_27 Vdout0_27ck162 = 0 time = 815
.meas tran vdout0_27ck162 FIND v(dout0_27) AT=815.025n

* CHECK dout0_28 Vdout0_28ck162 = 0 time = 815
.meas tran vdout0_28ck162 FIND v(dout0_28) AT=815.025n

* CHECK dout0_29 Vdout0_29ck162 = 0 time = 815
.meas tran vdout0_29ck162 FIND v(dout0_29) AT=815.025n

* CHECK dout0_30 Vdout0_30ck162 = 1.1 time = 815
.meas tran vdout0_30ck162 FIND v(dout0_30) AT=815.025n

* CHECK dout0_31 Vdout0_31ck162 = 1.1 time = 815
.meas tran vdout0_31ck162 FIND v(dout0_31) AT=815.025n

* CHECK dout0_0 Vdout0_0ck163 = 1.1 time = 820
.meas tran vdout0_0ck163 FIND v(dout0_0) AT=820.025n

* CHECK dout0_1 Vdout0_1ck163 = 1.1 time = 820
.meas tran vdout0_1ck163 FIND v(dout0_1) AT=820.025n

* CHECK dout0_2 Vdout0_2ck163 = 1.1 time = 820
.meas tran vdout0_2ck163 FIND v(dout0_2) AT=820.025n

* CHECK dout0_3 Vdout0_3ck163 = 0 time = 820
.meas tran vdout0_3ck163 FIND v(dout0_3) AT=820.025n

* CHECK dout0_4 Vdout0_4ck163 = 1.1 time = 820
.meas tran vdout0_4ck163 FIND v(dout0_4) AT=820.025n

* CHECK dout0_5 Vdout0_5ck163 = 0 time = 820
.meas tran vdout0_5ck163 FIND v(dout0_5) AT=820.025n

* CHECK dout0_6 Vdout0_6ck163 = 1.1 time = 820
.meas tran vdout0_6ck163 FIND v(dout0_6) AT=820.025n

* CHECK dout0_7 Vdout0_7ck163 = 0 time = 820
.meas tran vdout0_7ck163 FIND v(dout0_7) AT=820.025n

* CHECK dout0_8 Vdout0_8ck163 = 1.1 time = 820
.meas tran vdout0_8ck163 FIND v(dout0_8) AT=820.025n

* CHECK dout0_9 Vdout0_9ck163 = 1.1 time = 820
.meas tran vdout0_9ck163 FIND v(dout0_9) AT=820.025n

* CHECK dout0_10 Vdout0_10ck163 = 0 time = 820
.meas tran vdout0_10ck163 FIND v(dout0_10) AT=820.025n

* CHECK dout0_11 Vdout0_11ck163 = 0 time = 820
.meas tran vdout0_11ck163 FIND v(dout0_11) AT=820.025n

* CHECK dout0_12 Vdout0_12ck163 = 0 time = 820
.meas tran vdout0_12ck163 FIND v(dout0_12) AT=820.025n

* CHECK dout0_13 Vdout0_13ck163 = 0 time = 820
.meas tran vdout0_13ck163 FIND v(dout0_13) AT=820.025n

* CHECK dout0_14 Vdout0_14ck163 = 0 time = 820
.meas tran vdout0_14ck163 FIND v(dout0_14) AT=820.025n

* CHECK dout0_15 Vdout0_15ck163 = 1.1 time = 820
.meas tran vdout0_15ck163 FIND v(dout0_15) AT=820.025n

* CHECK dout0_16 Vdout0_16ck163 = 0 time = 820
.meas tran vdout0_16ck163 FIND v(dout0_16) AT=820.025n

* CHECK dout0_17 Vdout0_17ck163 = 1.1 time = 820
.meas tran vdout0_17ck163 FIND v(dout0_17) AT=820.025n

* CHECK dout0_18 Vdout0_18ck163 = 1.1 time = 820
.meas tran vdout0_18ck163 FIND v(dout0_18) AT=820.025n

* CHECK dout0_19 Vdout0_19ck163 = 0 time = 820
.meas tran vdout0_19ck163 FIND v(dout0_19) AT=820.025n

* CHECK dout0_20 Vdout0_20ck163 = 1.1 time = 820
.meas tran vdout0_20ck163 FIND v(dout0_20) AT=820.025n

* CHECK dout0_21 Vdout0_21ck163 = 0 time = 820
.meas tran vdout0_21ck163 FIND v(dout0_21) AT=820.025n

* CHECK dout0_22 Vdout0_22ck163 = 0 time = 820
.meas tran vdout0_22ck163 FIND v(dout0_22) AT=820.025n

* CHECK dout0_23 Vdout0_23ck163 = 0 time = 820
.meas tran vdout0_23ck163 FIND v(dout0_23) AT=820.025n

* CHECK dout0_24 Vdout0_24ck163 = 0 time = 820
.meas tran vdout0_24ck163 FIND v(dout0_24) AT=820.025n

* CHECK dout0_25 Vdout0_25ck163 = 1.1 time = 820
.meas tran vdout0_25ck163 FIND v(dout0_25) AT=820.025n

* CHECK dout0_26 Vdout0_26ck163 = 1.1 time = 820
.meas tran vdout0_26ck163 FIND v(dout0_26) AT=820.025n

* CHECK dout0_27 Vdout0_27ck163 = 0 time = 820
.meas tran vdout0_27ck163 FIND v(dout0_27) AT=820.025n

* CHECK dout0_28 Vdout0_28ck163 = 1.1 time = 820
.meas tran vdout0_28ck163 FIND v(dout0_28) AT=820.025n

* CHECK dout0_29 Vdout0_29ck163 = 0 time = 820
.meas tran vdout0_29ck163 FIND v(dout0_29) AT=820.025n

* CHECK dout0_30 Vdout0_30ck163 = 1.1 time = 820
.meas tran vdout0_30ck163 FIND v(dout0_30) AT=820.025n

* CHECK dout0_31 Vdout0_31ck163 = 1.1 time = 820
.meas tran vdout0_31ck163 FIND v(dout0_31) AT=820.025n

* CHECK dout0_0 Vdout0_0ck165 = 0 time = 830
.meas tran vdout0_0ck165 FIND v(dout0_0) AT=830.025n

* CHECK dout0_1 Vdout0_1ck165 = 0 time = 830
.meas tran vdout0_1ck165 FIND v(dout0_1) AT=830.025n

* CHECK dout0_2 Vdout0_2ck165 = 0 time = 830
.meas tran vdout0_2ck165 FIND v(dout0_2) AT=830.025n

* CHECK dout0_3 Vdout0_3ck165 = 1.1 time = 830
.meas tran vdout0_3ck165 FIND v(dout0_3) AT=830.025n

* CHECK dout0_4 Vdout0_4ck165 = 1.1 time = 830
.meas tran vdout0_4ck165 FIND v(dout0_4) AT=830.025n

* CHECK dout0_5 Vdout0_5ck165 = 1.1 time = 830
.meas tran vdout0_5ck165 FIND v(dout0_5) AT=830.025n

* CHECK dout0_6 Vdout0_6ck165 = 1.1 time = 830
.meas tran vdout0_6ck165 FIND v(dout0_6) AT=830.025n

* CHECK dout0_7 Vdout0_7ck165 = 1.1 time = 830
.meas tran vdout0_7ck165 FIND v(dout0_7) AT=830.025n

* CHECK dout0_8 Vdout0_8ck165 = 1.1 time = 830
.meas tran vdout0_8ck165 FIND v(dout0_8) AT=830.025n

* CHECK dout0_9 Vdout0_9ck165 = 0 time = 830
.meas tran vdout0_9ck165 FIND v(dout0_9) AT=830.025n

* CHECK dout0_10 Vdout0_10ck165 = 1.1 time = 830
.meas tran vdout0_10ck165 FIND v(dout0_10) AT=830.025n

* CHECK dout0_11 Vdout0_11ck165 = 0 time = 830
.meas tran vdout0_11ck165 FIND v(dout0_11) AT=830.025n

* CHECK dout0_12 Vdout0_12ck165 = 0 time = 830
.meas tran vdout0_12ck165 FIND v(dout0_12) AT=830.025n

* CHECK dout0_13 Vdout0_13ck165 = 0 time = 830
.meas tran vdout0_13ck165 FIND v(dout0_13) AT=830.025n

* CHECK dout0_14 Vdout0_14ck165 = 0 time = 830
.meas tran vdout0_14ck165 FIND v(dout0_14) AT=830.025n

* CHECK dout0_15 Vdout0_15ck165 = 0 time = 830
.meas tran vdout0_15ck165 FIND v(dout0_15) AT=830.025n

* CHECK dout0_16 Vdout0_16ck165 = 0 time = 830
.meas tran vdout0_16ck165 FIND v(dout0_16) AT=830.025n

* CHECK dout0_17 Vdout0_17ck165 = 1.1 time = 830
.meas tran vdout0_17ck165 FIND v(dout0_17) AT=830.025n

* CHECK dout0_18 Vdout0_18ck165 = 0 time = 830
.meas tran vdout0_18ck165 FIND v(dout0_18) AT=830.025n

* CHECK dout0_19 Vdout0_19ck165 = 0 time = 830
.meas tran vdout0_19ck165 FIND v(dout0_19) AT=830.025n

* CHECK dout0_20 Vdout0_20ck165 = 1.1 time = 830
.meas tran vdout0_20ck165 FIND v(dout0_20) AT=830.025n

* CHECK dout0_21 Vdout0_21ck165 = 1.1 time = 830
.meas tran vdout0_21ck165 FIND v(dout0_21) AT=830.025n

* CHECK dout0_22 Vdout0_22ck165 = 0 time = 830
.meas tran vdout0_22ck165 FIND v(dout0_22) AT=830.025n

* CHECK dout0_23 Vdout0_23ck165 = 1.1 time = 830
.meas tran vdout0_23ck165 FIND v(dout0_23) AT=830.025n

* CHECK dout0_24 Vdout0_24ck165 = 1.1 time = 830
.meas tran vdout0_24ck165 FIND v(dout0_24) AT=830.025n

* CHECK dout0_25 Vdout0_25ck165 = 1.1 time = 830
.meas tran vdout0_25ck165 FIND v(dout0_25) AT=830.025n

* CHECK dout0_26 Vdout0_26ck165 = 0 time = 830
.meas tran vdout0_26ck165 FIND v(dout0_26) AT=830.025n

* CHECK dout0_27 Vdout0_27ck165 = 0 time = 830
.meas tran vdout0_27ck165 FIND v(dout0_27) AT=830.025n

* CHECK dout0_28 Vdout0_28ck165 = 0 time = 830
.meas tran vdout0_28ck165 FIND v(dout0_28) AT=830.025n

* CHECK dout0_29 Vdout0_29ck165 = 1.1 time = 830
.meas tran vdout0_29ck165 FIND v(dout0_29) AT=830.025n

* CHECK dout0_30 Vdout0_30ck165 = 0 time = 830
.meas tran vdout0_30ck165 FIND v(dout0_30) AT=830.025n

* CHECK dout0_31 Vdout0_31ck165 = 0 time = 830
.meas tran vdout0_31ck165 FIND v(dout0_31) AT=830.025n

* CHECK dout0_0 Vdout0_0ck168 = 1.1 time = 845
.meas tran vdout0_0ck168 FIND v(dout0_0) AT=845.025n

* CHECK dout0_1 Vdout0_1ck168 = 0 time = 845
.meas tran vdout0_1ck168 FIND v(dout0_1) AT=845.025n

* CHECK dout0_2 Vdout0_2ck168 = 0 time = 845
.meas tran vdout0_2ck168 FIND v(dout0_2) AT=845.025n

* CHECK dout0_3 Vdout0_3ck168 = 1.1 time = 845
.meas tran vdout0_3ck168 FIND v(dout0_3) AT=845.025n

* CHECK dout0_4 Vdout0_4ck168 = 0 time = 845
.meas tran vdout0_4ck168 FIND v(dout0_4) AT=845.025n

* CHECK dout0_5 Vdout0_5ck168 = 1.1 time = 845
.meas tran vdout0_5ck168 FIND v(dout0_5) AT=845.025n

* CHECK dout0_6 Vdout0_6ck168 = 0 time = 845
.meas tran vdout0_6ck168 FIND v(dout0_6) AT=845.025n

* CHECK dout0_7 Vdout0_7ck168 = 0 time = 845
.meas tran vdout0_7ck168 FIND v(dout0_7) AT=845.025n

* CHECK dout0_8 Vdout0_8ck168 = 0 time = 845
.meas tran vdout0_8ck168 FIND v(dout0_8) AT=845.025n

* CHECK dout0_9 Vdout0_9ck168 = 0 time = 845
.meas tran vdout0_9ck168 FIND v(dout0_9) AT=845.025n

* CHECK dout0_10 Vdout0_10ck168 = 0 time = 845
.meas tran vdout0_10ck168 FIND v(dout0_10) AT=845.025n

* CHECK dout0_11 Vdout0_11ck168 = 1.1 time = 845
.meas tran vdout0_11ck168 FIND v(dout0_11) AT=845.025n

* CHECK dout0_12 Vdout0_12ck168 = 1.1 time = 845
.meas tran vdout0_12ck168 FIND v(dout0_12) AT=845.025n

* CHECK dout0_13 Vdout0_13ck168 = 0 time = 845
.meas tran vdout0_13ck168 FIND v(dout0_13) AT=845.025n

* CHECK dout0_14 Vdout0_14ck168 = 1.1 time = 845
.meas tran vdout0_14ck168 FIND v(dout0_14) AT=845.025n

* CHECK dout0_15 Vdout0_15ck168 = 1.1 time = 845
.meas tran vdout0_15ck168 FIND v(dout0_15) AT=845.025n

* CHECK dout0_16 Vdout0_16ck168 = 0 time = 845
.meas tran vdout0_16ck168 FIND v(dout0_16) AT=845.025n

* CHECK dout0_17 Vdout0_17ck168 = 0 time = 845
.meas tran vdout0_17ck168 FIND v(dout0_17) AT=845.025n

* CHECK dout0_18 Vdout0_18ck168 = 1.1 time = 845
.meas tran vdout0_18ck168 FIND v(dout0_18) AT=845.025n

* CHECK dout0_19 Vdout0_19ck168 = 0 time = 845
.meas tran vdout0_19ck168 FIND v(dout0_19) AT=845.025n

* CHECK dout0_20 Vdout0_20ck168 = 0 time = 845
.meas tran vdout0_20ck168 FIND v(dout0_20) AT=845.025n

* CHECK dout0_21 Vdout0_21ck168 = 1.1 time = 845
.meas tran vdout0_21ck168 FIND v(dout0_21) AT=845.025n

* CHECK dout0_22 Vdout0_22ck168 = 0 time = 845
.meas tran vdout0_22ck168 FIND v(dout0_22) AT=845.025n

* CHECK dout0_23 Vdout0_23ck168 = 0 time = 845
.meas tran vdout0_23ck168 FIND v(dout0_23) AT=845.025n

* CHECK dout0_24 Vdout0_24ck168 = 0 time = 845
.meas tran vdout0_24ck168 FIND v(dout0_24) AT=845.025n

* CHECK dout0_25 Vdout0_25ck168 = 0 time = 845
.meas tran vdout0_25ck168 FIND v(dout0_25) AT=845.025n

* CHECK dout0_26 Vdout0_26ck168 = 1.1 time = 845
.meas tran vdout0_26ck168 FIND v(dout0_26) AT=845.025n

* CHECK dout0_27 Vdout0_27ck168 = 1.1 time = 845
.meas tran vdout0_27ck168 FIND v(dout0_27) AT=845.025n

* CHECK dout0_28 Vdout0_28ck168 = 0 time = 845
.meas tran vdout0_28ck168 FIND v(dout0_28) AT=845.025n

* CHECK dout0_29 Vdout0_29ck168 = 1.1 time = 845
.meas tran vdout0_29ck168 FIND v(dout0_29) AT=845.025n

* CHECK dout0_30 Vdout0_30ck168 = 0 time = 845
.meas tran vdout0_30ck168 FIND v(dout0_30) AT=845.025n

* CHECK dout0_31 Vdout0_31ck168 = 0 time = 845
.meas tran vdout0_31ck168 FIND v(dout0_31) AT=845.025n

* CHECK dout0_0 Vdout0_0ck169 = 1.1 time = 850
.meas tran vdout0_0ck169 FIND v(dout0_0) AT=850.025n

* CHECK dout0_1 Vdout0_1ck169 = 0 time = 850
.meas tran vdout0_1ck169 FIND v(dout0_1) AT=850.025n

* CHECK dout0_2 Vdout0_2ck169 = 1.1 time = 850
.meas tran vdout0_2ck169 FIND v(dout0_2) AT=850.025n

* CHECK dout0_3 Vdout0_3ck169 = 1.1 time = 850
.meas tran vdout0_3ck169 FIND v(dout0_3) AT=850.025n

* CHECK dout0_4 Vdout0_4ck169 = 0 time = 850
.meas tran vdout0_4ck169 FIND v(dout0_4) AT=850.025n

* CHECK dout0_5 Vdout0_5ck169 = 0 time = 850
.meas tran vdout0_5ck169 FIND v(dout0_5) AT=850.025n

* CHECK dout0_6 Vdout0_6ck169 = 1.1 time = 850
.meas tran vdout0_6ck169 FIND v(dout0_6) AT=850.025n

* CHECK dout0_7 Vdout0_7ck169 = 0 time = 850
.meas tran vdout0_7ck169 FIND v(dout0_7) AT=850.025n

* CHECK dout0_8 Vdout0_8ck169 = 1.1 time = 850
.meas tran vdout0_8ck169 FIND v(dout0_8) AT=850.025n

* CHECK dout0_9 Vdout0_9ck169 = 0 time = 850
.meas tran vdout0_9ck169 FIND v(dout0_9) AT=850.025n

* CHECK dout0_10 Vdout0_10ck169 = 1.1 time = 850
.meas tran vdout0_10ck169 FIND v(dout0_10) AT=850.025n

* CHECK dout0_11 Vdout0_11ck169 = 1.1 time = 850
.meas tran vdout0_11ck169 FIND v(dout0_11) AT=850.025n

* CHECK dout0_12 Vdout0_12ck169 = 0 time = 850
.meas tran vdout0_12ck169 FIND v(dout0_12) AT=850.025n

* CHECK dout0_13 Vdout0_13ck169 = 1.1 time = 850
.meas tran vdout0_13ck169 FIND v(dout0_13) AT=850.025n

* CHECK dout0_14 Vdout0_14ck169 = 0 time = 850
.meas tran vdout0_14ck169 FIND v(dout0_14) AT=850.025n

* CHECK dout0_15 Vdout0_15ck169 = 1.1 time = 850
.meas tran vdout0_15ck169 FIND v(dout0_15) AT=850.025n

* CHECK dout0_16 Vdout0_16ck169 = 1.1 time = 850
.meas tran vdout0_16ck169 FIND v(dout0_16) AT=850.025n

* CHECK dout0_17 Vdout0_17ck169 = 1.1 time = 850
.meas tran vdout0_17ck169 FIND v(dout0_17) AT=850.025n

* CHECK dout0_18 Vdout0_18ck169 = 0 time = 850
.meas tran vdout0_18ck169 FIND v(dout0_18) AT=850.025n

* CHECK dout0_19 Vdout0_19ck169 = 0 time = 850
.meas tran vdout0_19ck169 FIND v(dout0_19) AT=850.025n

* CHECK dout0_20 Vdout0_20ck169 = 0 time = 850
.meas tran vdout0_20ck169 FIND v(dout0_20) AT=850.025n

* CHECK dout0_21 Vdout0_21ck169 = 0 time = 850
.meas tran vdout0_21ck169 FIND v(dout0_21) AT=850.025n

* CHECK dout0_22 Vdout0_22ck169 = 0 time = 850
.meas tran vdout0_22ck169 FIND v(dout0_22) AT=850.025n

* CHECK dout0_23 Vdout0_23ck169 = 1.1 time = 850
.meas tran vdout0_23ck169 FIND v(dout0_23) AT=850.025n

* CHECK dout0_24 Vdout0_24ck169 = 0 time = 850
.meas tran vdout0_24ck169 FIND v(dout0_24) AT=850.025n

* CHECK dout0_25 Vdout0_25ck169 = 0 time = 850
.meas tran vdout0_25ck169 FIND v(dout0_25) AT=850.025n

* CHECK dout0_26 Vdout0_26ck169 = 0 time = 850
.meas tran vdout0_26ck169 FIND v(dout0_26) AT=850.025n

* CHECK dout0_27 Vdout0_27ck169 = 1.1 time = 850
.meas tran vdout0_27ck169 FIND v(dout0_27) AT=850.025n

* CHECK dout0_28 Vdout0_28ck169 = 1.1 time = 850
.meas tran vdout0_28ck169 FIND v(dout0_28) AT=850.025n

* CHECK dout0_29 Vdout0_29ck169 = 1.1 time = 850
.meas tran vdout0_29ck169 FIND v(dout0_29) AT=850.025n

* CHECK dout0_30 Vdout0_30ck169 = 1.1 time = 850
.meas tran vdout0_30ck169 FIND v(dout0_30) AT=850.025n

* CHECK dout0_31 Vdout0_31ck169 = 0 time = 850
.meas tran vdout0_31ck169 FIND v(dout0_31) AT=850.025n

* CHECK dout0_0 Vdout0_0ck171 = 1.1 time = 860
.meas tran vdout0_0ck171 FIND v(dout0_0) AT=860.025n

* CHECK dout0_1 Vdout0_1ck171 = 0 time = 860
.meas tran vdout0_1ck171 FIND v(dout0_1) AT=860.025n

* CHECK dout0_2 Vdout0_2ck171 = 1.1 time = 860
.meas tran vdout0_2ck171 FIND v(dout0_2) AT=860.025n

* CHECK dout0_3 Vdout0_3ck171 = 1.1 time = 860
.meas tran vdout0_3ck171 FIND v(dout0_3) AT=860.025n

* CHECK dout0_4 Vdout0_4ck171 = 1.1 time = 860
.meas tran vdout0_4ck171 FIND v(dout0_4) AT=860.025n

* CHECK dout0_5 Vdout0_5ck171 = 0 time = 860
.meas tran vdout0_5ck171 FIND v(dout0_5) AT=860.025n

* CHECK dout0_6 Vdout0_6ck171 = 1.1 time = 860
.meas tran vdout0_6ck171 FIND v(dout0_6) AT=860.025n

* CHECK dout0_7 Vdout0_7ck171 = 1.1 time = 860
.meas tran vdout0_7ck171 FIND v(dout0_7) AT=860.025n

* CHECK dout0_8 Vdout0_8ck171 = 0 time = 860
.meas tran vdout0_8ck171 FIND v(dout0_8) AT=860.025n

* CHECK dout0_9 Vdout0_9ck171 = 0 time = 860
.meas tran vdout0_9ck171 FIND v(dout0_9) AT=860.025n

* CHECK dout0_10 Vdout0_10ck171 = 0 time = 860
.meas tran vdout0_10ck171 FIND v(dout0_10) AT=860.025n

* CHECK dout0_11 Vdout0_11ck171 = 1.1 time = 860
.meas tran vdout0_11ck171 FIND v(dout0_11) AT=860.025n

* CHECK dout0_12 Vdout0_12ck171 = 1.1 time = 860
.meas tran vdout0_12ck171 FIND v(dout0_12) AT=860.025n

* CHECK dout0_13 Vdout0_13ck171 = 1.1 time = 860
.meas tran vdout0_13ck171 FIND v(dout0_13) AT=860.025n

* CHECK dout0_14 Vdout0_14ck171 = 1.1 time = 860
.meas tran vdout0_14ck171 FIND v(dout0_14) AT=860.025n

* CHECK dout0_15 Vdout0_15ck171 = 1.1 time = 860
.meas tran vdout0_15ck171 FIND v(dout0_15) AT=860.025n

* CHECK dout0_16 Vdout0_16ck171 = 0 time = 860
.meas tran vdout0_16ck171 FIND v(dout0_16) AT=860.025n

* CHECK dout0_17 Vdout0_17ck171 = 0 time = 860
.meas tran vdout0_17ck171 FIND v(dout0_17) AT=860.025n

* CHECK dout0_18 Vdout0_18ck171 = 0 time = 860
.meas tran vdout0_18ck171 FIND v(dout0_18) AT=860.025n

* CHECK dout0_19 Vdout0_19ck171 = 1.1 time = 860
.meas tran vdout0_19ck171 FIND v(dout0_19) AT=860.025n

* CHECK dout0_20 Vdout0_20ck171 = 0 time = 860
.meas tran vdout0_20ck171 FIND v(dout0_20) AT=860.025n

* CHECK dout0_21 Vdout0_21ck171 = 1.1 time = 860
.meas tran vdout0_21ck171 FIND v(dout0_21) AT=860.025n

* CHECK dout0_22 Vdout0_22ck171 = 0 time = 860
.meas tran vdout0_22ck171 FIND v(dout0_22) AT=860.025n

* CHECK dout0_23 Vdout0_23ck171 = 1.1 time = 860
.meas tran vdout0_23ck171 FIND v(dout0_23) AT=860.025n

* CHECK dout0_24 Vdout0_24ck171 = 0 time = 860
.meas tran vdout0_24ck171 FIND v(dout0_24) AT=860.025n

* CHECK dout0_25 Vdout0_25ck171 = 1.1 time = 860
.meas tran vdout0_25ck171 FIND v(dout0_25) AT=860.025n

* CHECK dout0_26 Vdout0_26ck171 = 0 time = 860
.meas tran vdout0_26ck171 FIND v(dout0_26) AT=860.025n

* CHECK dout0_27 Vdout0_27ck171 = 1.1 time = 860
.meas tran vdout0_27ck171 FIND v(dout0_27) AT=860.025n

* CHECK dout0_28 Vdout0_28ck171 = 1.1 time = 860
.meas tran vdout0_28ck171 FIND v(dout0_28) AT=860.025n

* CHECK dout0_29 Vdout0_29ck171 = 0 time = 860
.meas tran vdout0_29ck171 FIND v(dout0_29) AT=860.025n

* CHECK dout0_30 Vdout0_30ck171 = 1.1 time = 860
.meas tran vdout0_30ck171 FIND v(dout0_30) AT=860.025n

* CHECK dout0_31 Vdout0_31ck171 = 1.1 time = 860
.meas tran vdout0_31ck171 FIND v(dout0_31) AT=860.025n

* CHECK dout0_0 Vdout0_0ck174 = 0 time = 875
.meas tran vdout0_0ck174 FIND v(dout0_0) AT=875.025n

* CHECK dout0_1 Vdout0_1ck174 = 1.1 time = 875
.meas tran vdout0_1ck174 FIND v(dout0_1) AT=875.025n

* CHECK dout0_2 Vdout0_2ck174 = 0 time = 875
.meas tran vdout0_2ck174 FIND v(dout0_2) AT=875.025n

* CHECK dout0_3 Vdout0_3ck174 = 0 time = 875
.meas tran vdout0_3ck174 FIND v(dout0_3) AT=875.025n

* CHECK dout0_4 Vdout0_4ck174 = 1.1 time = 875
.meas tran vdout0_4ck174 FIND v(dout0_4) AT=875.025n

* CHECK dout0_5 Vdout0_5ck174 = 0 time = 875
.meas tran vdout0_5ck174 FIND v(dout0_5) AT=875.025n

* CHECK dout0_6 Vdout0_6ck174 = 0 time = 875
.meas tran vdout0_6ck174 FIND v(dout0_6) AT=875.025n

* CHECK dout0_7 Vdout0_7ck174 = 1.1 time = 875
.meas tran vdout0_7ck174 FIND v(dout0_7) AT=875.025n

* CHECK dout0_8 Vdout0_8ck174 = 1.1 time = 875
.meas tran vdout0_8ck174 FIND v(dout0_8) AT=875.025n

* CHECK dout0_9 Vdout0_9ck174 = 1.1 time = 875
.meas tran vdout0_9ck174 FIND v(dout0_9) AT=875.025n

* CHECK dout0_10 Vdout0_10ck174 = 1.1 time = 875
.meas tran vdout0_10ck174 FIND v(dout0_10) AT=875.025n

* CHECK dout0_11 Vdout0_11ck174 = 0 time = 875
.meas tran vdout0_11ck174 FIND v(dout0_11) AT=875.025n

* CHECK dout0_12 Vdout0_12ck174 = 1.1 time = 875
.meas tran vdout0_12ck174 FIND v(dout0_12) AT=875.025n

* CHECK dout0_13 Vdout0_13ck174 = 0 time = 875
.meas tran vdout0_13ck174 FIND v(dout0_13) AT=875.025n

* CHECK dout0_14 Vdout0_14ck174 = 1.1 time = 875
.meas tran vdout0_14ck174 FIND v(dout0_14) AT=875.025n

* CHECK dout0_15 Vdout0_15ck174 = 0 time = 875
.meas tran vdout0_15ck174 FIND v(dout0_15) AT=875.025n

* CHECK dout0_16 Vdout0_16ck174 = 1.1 time = 875
.meas tran vdout0_16ck174 FIND v(dout0_16) AT=875.025n

* CHECK dout0_17 Vdout0_17ck174 = 0 time = 875
.meas tran vdout0_17ck174 FIND v(dout0_17) AT=875.025n

* CHECK dout0_18 Vdout0_18ck174 = 1.1 time = 875
.meas tran vdout0_18ck174 FIND v(dout0_18) AT=875.025n

* CHECK dout0_19 Vdout0_19ck174 = 0 time = 875
.meas tran vdout0_19ck174 FIND v(dout0_19) AT=875.025n

* CHECK dout0_20 Vdout0_20ck174 = 1.1 time = 875
.meas tran vdout0_20ck174 FIND v(dout0_20) AT=875.025n

* CHECK dout0_21 Vdout0_21ck174 = 0 time = 875
.meas tran vdout0_21ck174 FIND v(dout0_21) AT=875.025n

* CHECK dout0_22 Vdout0_22ck174 = 1.1 time = 875
.meas tran vdout0_22ck174 FIND v(dout0_22) AT=875.025n

* CHECK dout0_23 Vdout0_23ck174 = 0 time = 875
.meas tran vdout0_23ck174 FIND v(dout0_23) AT=875.025n

* CHECK dout0_24 Vdout0_24ck174 = 1.1 time = 875
.meas tran vdout0_24ck174 FIND v(dout0_24) AT=875.025n

* CHECK dout0_25 Vdout0_25ck174 = 1.1 time = 875
.meas tran vdout0_25ck174 FIND v(dout0_25) AT=875.025n

* CHECK dout0_26 Vdout0_26ck174 = 1.1 time = 875
.meas tran vdout0_26ck174 FIND v(dout0_26) AT=875.025n

* CHECK dout0_27 Vdout0_27ck174 = 0 time = 875
.meas tran vdout0_27ck174 FIND v(dout0_27) AT=875.025n

* CHECK dout0_28 Vdout0_28ck174 = 1.1 time = 875
.meas tran vdout0_28ck174 FIND v(dout0_28) AT=875.025n

* CHECK dout0_29 Vdout0_29ck174 = 0 time = 875
.meas tran vdout0_29ck174 FIND v(dout0_29) AT=875.025n

* CHECK dout0_30 Vdout0_30ck174 = 0 time = 875
.meas tran vdout0_30ck174 FIND v(dout0_30) AT=875.025n

* CHECK dout0_31 Vdout0_31ck174 = 1.1 time = 875
.meas tran vdout0_31ck174 FIND v(dout0_31) AT=875.025n

* CHECK dout0_0 Vdout0_0ck176 = 0 time = 885
.meas tran vdout0_0ck176 FIND v(dout0_0) AT=885.025n

* CHECK dout0_1 Vdout0_1ck176 = 0 time = 885
.meas tran vdout0_1ck176 FIND v(dout0_1) AT=885.025n

* CHECK dout0_2 Vdout0_2ck176 = 1.1 time = 885
.meas tran vdout0_2ck176 FIND v(dout0_2) AT=885.025n

* CHECK dout0_3 Vdout0_3ck176 = 0 time = 885
.meas tran vdout0_3ck176 FIND v(dout0_3) AT=885.025n

* CHECK dout0_4 Vdout0_4ck176 = 1.1 time = 885
.meas tran vdout0_4ck176 FIND v(dout0_4) AT=885.025n

* CHECK dout0_5 Vdout0_5ck176 = 0 time = 885
.meas tran vdout0_5ck176 FIND v(dout0_5) AT=885.025n

* CHECK dout0_6 Vdout0_6ck176 = 1.1 time = 885
.meas tran vdout0_6ck176 FIND v(dout0_6) AT=885.025n

* CHECK dout0_7 Vdout0_7ck176 = 0 time = 885
.meas tran vdout0_7ck176 FIND v(dout0_7) AT=885.025n

* CHECK dout0_8 Vdout0_8ck176 = 0 time = 885
.meas tran vdout0_8ck176 FIND v(dout0_8) AT=885.025n

* CHECK dout0_9 Vdout0_9ck176 = 1.1 time = 885
.meas tran vdout0_9ck176 FIND v(dout0_9) AT=885.025n

* CHECK dout0_10 Vdout0_10ck176 = 1.1 time = 885
.meas tran vdout0_10ck176 FIND v(dout0_10) AT=885.025n

* CHECK dout0_11 Vdout0_11ck176 = 1.1 time = 885
.meas tran vdout0_11ck176 FIND v(dout0_11) AT=885.025n

* CHECK dout0_12 Vdout0_12ck176 = 0 time = 885
.meas tran vdout0_12ck176 FIND v(dout0_12) AT=885.025n

* CHECK dout0_13 Vdout0_13ck176 = 1.1 time = 885
.meas tran vdout0_13ck176 FIND v(dout0_13) AT=885.025n

* CHECK dout0_14 Vdout0_14ck176 = 0 time = 885
.meas tran vdout0_14ck176 FIND v(dout0_14) AT=885.025n

* CHECK dout0_15 Vdout0_15ck176 = 0 time = 885
.meas tran vdout0_15ck176 FIND v(dout0_15) AT=885.025n

* CHECK dout0_16 Vdout0_16ck176 = 1.1 time = 885
.meas tran vdout0_16ck176 FIND v(dout0_16) AT=885.025n

* CHECK dout0_17 Vdout0_17ck176 = 1.1 time = 885
.meas tran vdout0_17ck176 FIND v(dout0_17) AT=885.025n

* CHECK dout0_18 Vdout0_18ck176 = 1.1 time = 885
.meas tran vdout0_18ck176 FIND v(dout0_18) AT=885.025n

* CHECK dout0_19 Vdout0_19ck176 = 0 time = 885
.meas tran vdout0_19ck176 FIND v(dout0_19) AT=885.025n

* CHECK dout0_20 Vdout0_20ck176 = 1.1 time = 885
.meas tran vdout0_20ck176 FIND v(dout0_20) AT=885.025n

* CHECK dout0_21 Vdout0_21ck176 = 1.1 time = 885
.meas tran vdout0_21ck176 FIND v(dout0_21) AT=885.025n

* CHECK dout0_22 Vdout0_22ck176 = 0 time = 885
.meas tran vdout0_22ck176 FIND v(dout0_22) AT=885.025n

* CHECK dout0_23 Vdout0_23ck176 = 0 time = 885
.meas tran vdout0_23ck176 FIND v(dout0_23) AT=885.025n

* CHECK dout0_24 Vdout0_24ck176 = 0 time = 885
.meas tran vdout0_24ck176 FIND v(dout0_24) AT=885.025n

* CHECK dout0_25 Vdout0_25ck176 = 1.1 time = 885
.meas tran vdout0_25ck176 FIND v(dout0_25) AT=885.025n

* CHECK dout0_26 Vdout0_26ck176 = 1.1 time = 885
.meas tran vdout0_26ck176 FIND v(dout0_26) AT=885.025n

* CHECK dout0_27 Vdout0_27ck176 = 0 time = 885
.meas tran vdout0_27ck176 FIND v(dout0_27) AT=885.025n

* CHECK dout0_28 Vdout0_28ck176 = 0 time = 885
.meas tran vdout0_28ck176 FIND v(dout0_28) AT=885.025n

* CHECK dout0_29 Vdout0_29ck176 = 0 time = 885
.meas tran vdout0_29ck176 FIND v(dout0_29) AT=885.025n

* CHECK dout0_30 Vdout0_30ck176 = 0 time = 885
.meas tran vdout0_30ck176 FIND v(dout0_30) AT=885.025n

* CHECK dout0_31 Vdout0_31ck176 = 1.1 time = 885
.meas tran vdout0_31ck176 FIND v(dout0_31) AT=885.025n

* CHECK dout0_0 Vdout0_0ck177 = 0 time = 890
.meas tran vdout0_0ck177 FIND v(dout0_0) AT=890.025n

* CHECK dout0_1 Vdout0_1ck177 = 1.1 time = 890
.meas tran vdout0_1ck177 FIND v(dout0_1) AT=890.025n

* CHECK dout0_2 Vdout0_2ck177 = 0 time = 890
.meas tran vdout0_2ck177 FIND v(dout0_2) AT=890.025n

* CHECK dout0_3 Vdout0_3ck177 = 0 time = 890
.meas tran vdout0_3ck177 FIND v(dout0_3) AT=890.025n

* CHECK dout0_4 Vdout0_4ck177 = 1.1 time = 890
.meas tran vdout0_4ck177 FIND v(dout0_4) AT=890.025n

* CHECK dout0_5 Vdout0_5ck177 = 0 time = 890
.meas tran vdout0_5ck177 FIND v(dout0_5) AT=890.025n

* CHECK dout0_6 Vdout0_6ck177 = 0 time = 890
.meas tran vdout0_6ck177 FIND v(dout0_6) AT=890.025n

* CHECK dout0_7 Vdout0_7ck177 = 1.1 time = 890
.meas tran vdout0_7ck177 FIND v(dout0_7) AT=890.025n

* CHECK dout0_8 Vdout0_8ck177 = 1.1 time = 890
.meas tran vdout0_8ck177 FIND v(dout0_8) AT=890.025n

* CHECK dout0_9 Vdout0_9ck177 = 1.1 time = 890
.meas tran vdout0_9ck177 FIND v(dout0_9) AT=890.025n

* CHECK dout0_10 Vdout0_10ck177 = 1.1 time = 890
.meas tran vdout0_10ck177 FIND v(dout0_10) AT=890.025n

* CHECK dout0_11 Vdout0_11ck177 = 0 time = 890
.meas tran vdout0_11ck177 FIND v(dout0_11) AT=890.025n

* CHECK dout0_12 Vdout0_12ck177 = 1.1 time = 890
.meas tran vdout0_12ck177 FIND v(dout0_12) AT=890.025n

* CHECK dout0_13 Vdout0_13ck177 = 0 time = 890
.meas tran vdout0_13ck177 FIND v(dout0_13) AT=890.025n

* CHECK dout0_14 Vdout0_14ck177 = 1.1 time = 890
.meas tran vdout0_14ck177 FIND v(dout0_14) AT=890.025n

* CHECK dout0_15 Vdout0_15ck177 = 0 time = 890
.meas tran vdout0_15ck177 FIND v(dout0_15) AT=890.025n

* CHECK dout0_16 Vdout0_16ck177 = 1.1 time = 890
.meas tran vdout0_16ck177 FIND v(dout0_16) AT=890.025n

* CHECK dout0_17 Vdout0_17ck177 = 0 time = 890
.meas tran vdout0_17ck177 FIND v(dout0_17) AT=890.025n

* CHECK dout0_18 Vdout0_18ck177 = 1.1 time = 890
.meas tran vdout0_18ck177 FIND v(dout0_18) AT=890.025n

* CHECK dout0_19 Vdout0_19ck177 = 0 time = 890
.meas tran vdout0_19ck177 FIND v(dout0_19) AT=890.025n

* CHECK dout0_20 Vdout0_20ck177 = 1.1 time = 890
.meas tran vdout0_20ck177 FIND v(dout0_20) AT=890.025n

* CHECK dout0_21 Vdout0_21ck177 = 0 time = 890
.meas tran vdout0_21ck177 FIND v(dout0_21) AT=890.025n

* CHECK dout0_22 Vdout0_22ck177 = 1.1 time = 890
.meas tran vdout0_22ck177 FIND v(dout0_22) AT=890.025n

* CHECK dout0_23 Vdout0_23ck177 = 0 time = 890
.meas tran vdout0_23ck177 FIND v(dout0_23) AT=890.025n

* CHECK dout0_24 Vdout0_24ck177 = 1.1 time = 890
.meas tran vdout0_24ck177 FIND v(dout0_24) AT=890.025n

* CHECK dout0_25 Vdout0_25ck177 = 1.1 time = 890
.meas tran vdout0_25ck177 FIND v(dout0_25) AT=890.025n

* CHECK dout0_26 Vdout0_26ck177 = 1.1 time = 890
.meas tran vdout0_26ck177 FIND v(dout0_26) AT=890.025n

* CHECK dout0_27 Vdout0_27ck177 = 0 time = 890
.meas tran vdout0_27ck177 FIND v(dout0_27) AT=890.025n

* CHECK dout0_28 Vdout0_28ck177 = 1.1 time = 890
.meas tran vdout0_28ck177 FIND v(dout0_28) AT=890.025n

* CHECK dout0_29 Vdout0_29ck177 = 0 time = 890
.meas tran vdout0_29ck177 FIND v(dout0_29) AT=890.025n

* CHECK dout0_30 Vdout0_30ck177 = 0 time = 890
.meas tran vdout0_30ck177 FIND v(dout0_30) AT=890.025n

* CHECK dout0_31 Vdout0_31ck177 = 1.1 time = 890
.meas tran vdout0_31ck177 FIND v(dout0_31) AT=890.025n

* CHECK dout0_0 Vdout0_0ck178 = 1.1 time = 895
.meas tran vdout0_0ck178 FIND v(dout0_0) AT=895.025n

* CHECK dout0_1 Vdout0_1ck178 = 0 time = 895
.meas tran vdout0_1ck178 FIND v(dout0_1) AT=895.025n

* CHECK dout0_2 Vdout0_2ck178 = 1.1 time = 895
.meas tran vdout0_2ck178 FIND v(dout0_2) AT=895.025n

* CHECK dout0_3 Vdout0_3ck178 = 1.1 time = 895
.meas tran vdout0_3ck178 FIND v(dout0_3) AT=895.025n

* CHECK dout0_4 Vdout0_4ck178 = 0 time = 895
.meas tran vdout0_4ck178 FIND v(dout0_4) AT=895.025n

* CHECK dout0_5 Vdout0_5ck178 = 0 time = 895
.meas tran vdout0_5ck178 FIND v(dout0_5) AT=895.025n

* CHECK dout0_6 Vdout0_6ck178 = 1.1 time = 895
.meas tran vdout0_6ck178 FIND v(dout0_6) AT=895.025n

* CHECK dout0_7 Vdout0_7ck178 = 0 time = 895
.meas tran vdout0_7ck178 FIND v(dout0_7) AT=895.025n

* CHECK dout0_8 Vdout0_8ck178 = 1.1 time = 895
.meas tran vdout0_8ck178 FIND v(dout0_8) AT=895.025n

* CHECK dout0_9 Vdout0_9ck178 = 0 time = 895
.meas tran vdout0_9ck178 FIND v(dout0_9) AT=895.025n

* CHECK dout0_10 Vdout0_10ck178 = 1.1 time = 895
.meas tran vdout0_10ck178 FIND v(dout0_10) AT=895.025n

* CHECK dout0_11 Vdout0_11ck178 = 1.1 time = 895
.meas tran vdout0_11ck178 FIND v(dout0_11) AT=895.025n

* CHECK dout0_12 Vdout0_12ck178 = 0 time = 895
.meas tran vdout0_12ck178 FIND v(dout0_12) AT=895.025n

* CHECK dout0_13 Vdout0_13ck178 = 1.1 time = 895
.meas tran vdout0_13ck178 FIND v(dout0_13) AT=895.025n

* CHECK dout0_14 Vdout0_14ck178 = 0 time = 895
.meas tran vdout0_14ck178 FIND v(dout0_14) AT=895.025n

* CHECK dout0_15 Vdout0_15ck178 = 1.1 time = 895
.meas tran vdout0_15ck178 FIND v(dout0_15) AT=895.025n

* CHECK dout0_16 Vdout0_16ck178 = 1.1 time = 895
.meas tran vdout0_16ck178 FIND v(dout0_16) AT=895.025n

* CHECK dout0_17 Vdout0_17ck178 = 1.1 time = 895
.meas tran vdout0_17ck178 FIND v(dout0_17) AT=895.025n

* CHECK dout0_18 Vdout0_18ck178 = 0 time = 895
.meas tran vdout0_18ck178 FIND v(dout0_18) AT=895.025n

* CHECK dout0_19 Vdout0_19ck178 = 0 time = 895
.meas tran vdout0_19ck178 FIND v(dout0_19) AT=895.025n

* CHECK dout0_20 Vdout0_20ck178 = 0 time = 895
.meas tran vdout0_20ck178 FIND v(dout0_20) AT=895.025n

* CHECK dout0_21 Vdout0_21ck178 = 0 time = 895
.meas tran vdout0_21ck178 FIND v(dout0_21) AT=895.025n

* CHECK dout0_22 Vdout0_22ck178 = 0 time = 895
.meas tran vdout0_22ck178 FIND v(dout0_22) AT=895.025n

* CHECK dout0_23 Vdout0_23ck178 = 1.1 time = 895
.meas tran vdout0_23ck178 FIND v(dout0_23) AT=895.025n

* CHECK dout0_24 Vdout0_24ck178 = 0 time = 895
.meas tran vdout0_24ck178 FIND v(dout0_24) AT=895.025n

* CHECK dout0_25 Vdout0_25ck178 = 0 time = 895
.meas tran vdout0_25ck178 FIND v(dout0_25) AT=895.025n

* CHECK dout0_26 Vdout0_26ck178 = 0 time = 895
.meas tran vdout0_26ck178 FIND v(dout0_26) AT=895.025n

* CHECK dout0_27 Vdout0_27ck178 = 1.1 time = 895
.meas tran vdout0_27ck178 FIND v(dout0_27) AT=895.025n

* CHECK dout0_28 Vdout0_28ck178 = 1.1 time = 895
.meas tran vdout0_28ck178 FIND v(dout0_28) AT=895.025n

* CHECK dout0_29 Vdout0_29ck178 = 1.1 time = 895
.meas tran vdout0_29ck178 FIND v(dout0_29) AT=895.025n

* CHECK dout0_30 Vdout0_30ck178 = 1.1 time = 895
.meas tran vdout0_30ck178 FIND v(dout0_30) AT=895.025n

* CHECK dout0_31 Vdout0_31ck178 = 0 time = 895
.meas tran vdout0_31ck178 FIND v(dout0_31) AT=895.025n

* CHECK dout0_0 Vdout0_0ck180 = 1.1 time = 905
.meas tran vdout0_0ck180 FIND v(dout0_0) AT=905.025n

* CHECK dout0_1 Vdout0_1ck180 = 0 time = 905
.meas tran vdout0_1ck180 FIND v(dout0_1) AT=905.025n

* CHECK dout0_2 Vdout0_2ck180 = 1.1 time = 905
.meas tran vdout0_2ck180 FIND v(dout0_2) AT=905.025n

* CHECK dout0_3 Vdout0_3ck180 = 1.1 time = 905
.meas tran vdout0_3ck180 FIND v(dout0_3) AT=905.025n

* CHECK dout0_4 Vdout0_4ck180 = 1.1 time = 905
.meas tran vdout0_4ck180 FIND v(dout0_4) AT=905.025n

* CHECK dout0_5 Vdout0_5ck180 = 0 time = 905
.meas tran vdout0_5ck180 FIND v(dout0_5) AT=905.025n

* CHECK dout0_6 Vdout0_6ck180 = 1.1 time = 905
.meas tran vdout0_6ck180 FIND v(dout0_6) AT=905.025n

* CHECK dout0_7 Vdout0_7ck180 = 1.1 time = 905
.meas tran vdout0_7ck180 FIND v(dout0_7) AT=905.025n

* CHECK dout0_8 Vdout0_8ck180 = 0 time = 905
.meas tran vdout0_8ck180 FIND v(dout0_8) AT=905.025n

* CHECK dout0_9 Vdout0_9ck180 = 0 time = 905
.meas tran vdout0_9ck180 FIND v(dout0_9) AT=905.025n

* CHECK dout0_10 Vdout0_10ck180 = 0 time = 905
.meas tran vdout0_10ck180 FIND v(dout0_10) AT=905.025n

* CHECK dout0_11 Vdout0_11ck180 = 1.1 time = 905
.meas tran vdout0_11ck180 FIND v(dout0_11) AT=905.025n

* CHECK dout0_12 Vdout0_12ck180 = 1.1 time = 905
.meas tran vdout0_12ck180 FIND v(dout0_12) AT=905.025n

* CHECK dout0_13 Vdout0_13ck180 = 1.1 time = 905
.meas tran vdout0_13ck180 FIND v(dout0_13) AT=905.025n

* CHECK dout0_14 Vdout0_14ck180 = 1.1 time = 905
.meas tran vdout0_14ck180 FIND v(dout0_14) AT=905.025n

* CHECK dout0_15 Vdout0_15ck180 = 1.1 time = 905
.meas tran vdout0_15ck180 FIND v(dout0_15) AT=905.025n

* CHECK dout0_16 Vdout0_16ck180 = 0 time = 905
.meas tran vdout0_16ck180 FIND v(dout0_16) AT=905.025n

* CHECK dout0_17 Vdout0_17ck180 = 0 time = 905
.meas tran vdout0_17ck180 FIND v(dout0_17) AT=905.025n

* CHECK dout0_18 Vdout0_18ck180 = 0 time = 905
.meas tran vdout0_18ck180 FIND v(dout0_18) AT=905.025n

* CHECK dout0_19 Vdout0_19ck180 = 1.1 time = 905
.meas tran vdout0_19ck180 FIND v(dout0_19) AT=905.025n

* CHECK dout0_20 Vdout0_20ck180 = 0 time = 905
.meas tran vdout0_20ck180 FIND v(dout0_20) AT=905.025n

* CHECK dout0_21 Vdout0_21ck180 = 1.1 time = 905
.meas tran vdout0_21ck180 FIND v(dout0_21) AT=905.025n

* CHECK dout0_22 Vdout0_22ck180 = 0 time = 905
.meas tran vdout0_22ck180 FIND v(dout0_22) AT=905.025n

* CHECK dout0_23 Vdout0_23ck180 = 1.1 time = 905
.meas tran vdout0_23ck180 FIND v(dout0_23) AT=905.025n

* CHECK dout0_24 Vdout0_24ck180 = 0 time = 905
.meas tran vdout0_24ck180 FIND v(dout0_24) AT=905.025n

* CHECK dout0_25 Vdout0_25ck180 = 1.1 time = 905
.meas tran vdout0_25ck180 FIND v(dout0_25) AT=905.025n

* CHECK dout0_26 Vdout0_26ck180 = 0 time = 905
.meas tran vdout0_26ck180 FIND v(dout0_26) AT=905.025n

* CHECK dout0_27 Vdout0_27ck180 = 1.1 time = 905
.meas tran vdout0_27ck180 FIND v(dout0_27) AT=905.025n

* CHECK dout0_28 Vdout0_28ck180 = 1.1 time = 905
.meas tran vdout0_28ck180 FIND v(dout0_28) AT=905.025n

* CHECK dout0_29 Vdout0_29ck180 = 0 time = 905
.meas tran vdout0_29ck180 FIND v(dout0_29) AT=905.025n

* CHECK dout0_30 Vdout0_30ck180 = 1.1 time = 905
.meas tran vdout0_30ck180 FIND v(dout0_30) AT=905.025n

* CHECK dout0_31 Vdout0_31ck180 = 1.1 time = 905
.meas tran vdout0_31ck180 FIND v(dout0_31) AT=905.025n

* CHECK dout0_0 Vdout0_0ck182 = 1.1 time = 915
.meas tran vdout0_0ck182 FIND v(dout0_0) AT=915.025n

* CHECK dout0_1 Vdout0_1ck182 = 0 time = 915
.meas tran vdout0_1ck182 FIND v(dout0_1) AT=915.025n

* CHECK dout0_2 Vdout0_2ck182 = 0 time = 915
.meas tran vdout0_2ck182 FIND v(dout0_2) AT=915.025n

* CHECK dout0_3 Vdout0_3ck182 = 1.1 time = 915
.meas tran vdout0_3ck182 FIND v(dout0_3) AT=915.025n

* CHECK dout0_4 Vdout0_4ck182 = 0 time = 915
.meas tran vdout0_4ck182 FIND v(dout0_4) AT=915.025n

* CHECK dout0_5 Vdout0_5ck182 = 0 time = 915
.meas tran vdout0_5ck182 FIND v(dout0_5) AT=915.025n

* CHECK dout0_6 Vdout0_6ck182 = 1.1 time = 915
.meas tran vdout0_6ck182 FIND v(dout0_6) AT=915.025n

* CHECK dout0_7 Vdout0_7ck182 = 0 time = 915
.meas tran vdout0_7ck182 FIND v(dout0_7) AT=915.025n

* CHECK dout0_8 Vdout0_8ck182 = 1.1 time = 915
.meas tran vdout0_8ck182 FIND v(dout0_8) AT=915.025n

* CHECK dout0_9 Vdout0_9ck182 = 0 time = 915
.meas tran vdout0_9ck182 FIND v(dout0_9) AT=915.025n

* CHECK dout0_10 Vdout0_10ck182 = 1.1 time = 915
.meas tran vdout0_10ck182 FIND v(dout0_10) AT=915.025n

* CHECK dout0_11 Vdout0_11ck182 = 1.1 time = 915
.meas tran vdout0_11ck182 FIND v(dout0_11) AT=915.025n

* CHECK dout0_12 Vdout0_12ck182 = 1.1 time = 915
.meas tran vdout0_12ck182 FIND v(dout0_12) AT=915.025n

* CHECK dout0_13 Vdout0_13ck182 = 1.1 time = 915
.meas tran vdout0_13ck182 FIND v(dout0_13) AT=915.025n

* CHECK dout0_14 Vdout0_14ck182 = 1.1 time = 915
.meas tran vdout0_14ck182 FIND v(dout0_14) AT=915.025n

* CHECK dout0_15 Vdout0_15ck182 = 0 time = 915
.meas tran vdout0_15ck182 FIND v(dout0_15) AT=915.025n

* CHECK dout0_16 Vdout0_16ck182 = 1.1 time = 915
.meas tran vdout0_16ck182 FIND v(dout0_16) AT=915.025n

* CHECK dout0_17 Vdout0_17ck182 = 1.1 time = 915
.meas tran vdout0_17ck182 FIND v(dout0_17) AT=915.025n

* CHECK dout0_18 Vdout0_18ck182 = 1.1 time = 915
.meas tran vdout0_18ck182 FIND v(dout0_18) AT=915.025n

* CHECK dout0_19 Vdout0_19ck182 = 1.1 time = 915
.meas tran vdout0_19ck182 FIND v(dout0_19) AT=915.025n

* CHECK dout0_20 Vdout0_20ck182 = 0 time = 915
.meas tran vdout0_20ck182 FIND v(dout0_20) AT=915.025n

* CHECK dout0_21 Vdout0_21ck182 = 0 time = 915
.meas tran vdout0_21ck182 FIND v(dout0_21) AT=915.025n

* CHECK dout0_22 Vdout0_22ck182 = 0 time = 915
.meas tran vdout0_22ck182 FIND v(dout0_22) AT=915.025n

* CHECK dout0_23 Vdout0_23ck182 = 1.1 time = 915
.meas tran vdout0_23ck182 FIND v(dout0_23) AT=915.025n

* CHECK dout0_24 Vdout0_24ck182 = 0 time = 915
.meas tran vdout0_24ck182 FIND v(dout0_24) AT=915.025n

* CHECK dout0_25 Vdout0_25ck182 = 0 time = 915
.meas tran vdout0_25ck182 FIND v(dout0_25) AT=915.025n

* CHECK dout0_26 Vdout0_26ck182 = 1.1 time = 915
.meas tran vdout0_26ck182 FIND v(dout0_26) AT=915.025n

* CHECK dout0_27 Vdout0_27ck182 = 0 time = 915
.meas tran vdout0_27ck182 FIND v(dout0_27) AT=915.025n

* CHECK dout0_28 Vdout0_28ck182 = 0 time = 915
.meas tran vdout0_28ck182 FIND v(dout0_28) AT=915.025n

* CHECK dout0_29 Vdout0_29ck182 = 1.1 time = 915
.meas tran vdout0_29ck182 FIND v(dout0_29) AT=915.025n

* CHECK dout0_30 Vdout0_30ck182 = 1.1 time = 915
.meas tran vdout0_30ck182 FIND v(dout0_30) AT=915.025n

* CHECK dout0_31 Vdout0_31ck182 = 0 time = 915
.meas tran vdout0_31ck182 FIND v(dout0_31) AT=915.025n

* CHECK dout0_0 Vdout0_0ck184 = 1.1 time = 925
.meas tran vdout0_0ck184 FIND v(dout0_0) AT=925.025n

* CHECK dout0_1 Vdout0_1ck184 = 0 time = 925
.meas tran vdout0_1ck184 FIND v(dout0_1) AT=925.025n

* CHECK dout0_2 Vdout0_2ck184 = 1.1 time = 925
.meas tran vdout0_2ck184 FIND v(dout0_2) AT=925.025n

* CHECK dout0_3 Vdout0_3ck184 = 1.1 time = 925
.meas tran vdout0_3ck184 FIND v(dout0_3) AT=925.025n

* CHECK dout0_4 Vdout0_4ck184 = 0 time = 925
.meas tran vdout0_4ck184 FIND v(dout0_4) AT=925.025n

* CHECK dout0_5 Vdout0_5ck184 = 0 time = 925
.meas tran vdout0_5ck184 FIND v(dout0_5) AT=925.025n

* CHECK dout0_6 Vdout0_6ck184 = 1.1 time = 925
.meas tran vdout0_6ck184 FIND v(dout0_6) AT=925.025n

* CHECK dout0_7 Vdout0_7ck184 = 0 time = 925
.meas tran vdout0_7ck184 FIND v(dout0_7) AT=925.025n

* CHECK dout0_8 Vdout0_8ck184 = 1.1 time = 925
.meas tran vdout0_8ck184 FIND v(dout0_8) AT=925.025n

* CHECK dout0_9 Vdout0_9ck184 = 0 time = 925
.meas tran vdout0_9ck184 FIND v(dout0_9) AT=925.025n

* CHECK dout0_10 Vdout0_10ck184 = 1.1 time = 925
.meas tran vdout0_10ck184 FIND v(dout0_10) AT=925.025n

* CHECK dout0_11 Vdout0_11ck184 = 1.1 time = 925
.meas tran vdout0_11ck184 FIND v(dout0_11) AT=925.025n

* CHECK dout0_12 Vdout0_12ck184 = 0 time = 925
.meas tran vdout0_12ck184 FIND v(dout0_12) AT=925.025n

* CHECK dout0_13 Vdout0_13ck184 = 1.1 time = 925
.meas tran vdout0_13ck184 FIND v(dout0_13) AT=925.025n

* CHECK dout0_14 Vdout0_14ck184 = 0 time = 925
.meas tran vdout0_14ck184 FIND v(dout0_14) AT=925.025n

* CHECK dout0_15 Vdout0_15ck184 = 1.1 time = 925
.meas tran vdout0_15ck184 FIND v(dout0_15) AT=925.025n

* CHECK dout0_16 Vdout0_16ck184 = 1.1 time = 925
.meas tran vdout0_16ck184 FIND v(dout0_16) AT=925.025n

* CHECK dout0_17 Vdout0_17ck184 = 1.1 time = 925
.meas tran vdout0_17ck184 FIND v(dout0_17) AT=925.025n

* CHECK dout0_18 Vdout0_18ck184 = 0 time = 925
.meas tran vdout0_18ck184 FIND v(dout0_18) AT=925.025n

* CHECK dout0_19 Vdout0_19ck184 = 0 time = 925
.meas tran vdout0_19ck184 FIND v(dout0_19) AT=925.025n

* CHECK dout0_20 Vdout0_20ck184 = 0 time = 925
.meas tran vdout0_20ck184 FIND v(dout0_20) AT=925.025n

* CHECK dout0_21 Vdout0_21ck184 = 0 time = 925
.meas tran vdout0_21ck184 FIND v(dout0_21) AT=925.025n

* CHECK dout0_22 Vdout0_22ck184 = 0 time = 925
.meas tran vdout0_22ck184 FIND v(dout0_22) AT=925.025n

* CHECK dout0_23 Vdout0_23ck184 = 1.1 time = 925
.meas tran vdout0_23ck184 FIND v(dout0_23) AT=925.025n

* CHECK dout0_24 Vdout0_24ck184 = 0 time = 925
.meas tran vdout0_24ck184 FIND v(dout0_24) AT=925.025n

* CHECK dout0_25 Vdout0_25ck184 = 0 time = 925
.meas tran vdout0_25ck184 FIND v(dout0_25) AT=925.025n

* CHECK dout0_26 Vdout0_26ck184 = 0 time = 925
.meas tran vdout0_26ck184 FIND v(dout0_26) AT=925.025n

* CHECK dout0_27 Vdout0_27ck184 = 1.1 time = 925
.meas tran vdout0_27ck184 FIND v(dout0_27) AT=925.025n

* CHECK dout0_28 Vdout0_28ck184 = 1.1 time = 925
.meas tran vdout0_28ck184 FIND v(dout0_28) AT=925.025n

* CHECK dout0_29 Vdout0_29ck184 = 1.1 time = 925
.meas tran vdout0_29ck184 FIND v(dout0_29) AT=925.025n

* CHECK dout0_30 Vdout0_30ck184 = 1.1 time = 925
.meas tran vdout0_30ck184 FIND v(dout0_30) AT=925.025n

* CHECK dout0_31 Vdout0_31ck184 = 0 time = 925
.meas tran vdout0_31ck184 FIND v(dout0_31) AT=925.025n

* CHECK dout0_0 Vdout0_0ck185 = 1.1 time = 930
.meas tran vdout0_0ck185 FIND v(dout0_0) AT=930.025n

* CHECK dout0_1 Vdout0_1ck185 = 0 time = 930
.meas tran vdout0_1ck185 FIND v(dout0_1) AT=930.025n

* CHECK dout0_2 Vdout0_2ck185 = 1.1 time = 930
.meas tran vdout0_2ck185 FIND v(dout0_2) AT=930.025n

* CHECK dout0_3 Vdout0_3ck185 = 1.1 time = 930
.meas tran vdout0_3ck185 FIND v(dout0_3) AT=930.025n

* CHECK dout0_4 Vdout0_4ck185 = 1.1 time = 930
.meas tran vdout0_4ck185 FIND v(dout0_4) AT=930.025n

* CHECK dout0_5 Vdout0_5ck185 = 0 time = 930
.meas tran vdout0_5ck185 FIND v(dout0_5) AT=930.025n

* CHECK dout0_6 Vdout0_6ck185 = 1.1 time = 930
.meas tran vdout0_6ck185 FIND v(dout0_6) AT=930.025n

* CHECK dout0_7 Vdout0_7ck185 = 1.1 time = 930
.meas tran vdout0_7ck185 FIND v(dout0_7) AT=930.025n

* CHECK dout0_8 Vdout0_8ck185 = 0 time = 930
.meas tran vdout0_8ck185 FIND v(dout0_8) AT=930.025n

* CHECK dout0_9 Vdout0_9ck185 = 0 time = 930
.meas tran vdout0_9ck185 FIND v(dout0_9) AT=930.025n

* CHECK dout0_10 Vdout0_10ck185 = 0 time = 930
.meas tran vdout0_10ck185 FIND v(dout0_10) AT=930.025n

* CHECK dout0_11 Vdout0_11ck185 = 1.1 time = 930
.meas tran vdout0_11ck185 FIND v(dout0_11) AT=930.025n

* CHECK dout0_12 Vdout0_12ck185 = 1.1 time = 930
.meas tran vdout0_12ck185 FIND v(dout0_12) AT=930.025n

* CHECK dout0_13 Vdout0_13ck185 = 1.1 time = 930
.meas tran vdout0_13ck185 FIND v(dout0_13) AT=930.025n

* CHECK dout0_14 Vdout0_14ck185 = 1.1 time = 930
.meas tran vdout0_14ck185 FIND v(dout0_14) AT=930.025n

* CHECK dout0_15 Vdout0_15ck185 = 1.1 time = 930
.meas tran vdout0_15ck185 FIND v(dout0_15) AT=930.025n

* CHECK dout0_16 Vdout0_16ck185 = 0 time = 930
.meas tran vdout0_16ck185 FIND v(dout0_16) AT=930.025n

* CHECK dout0_17 Vdout0_17ck185 = 0 time = 930
.meas tran vdout0_17ck185 FIND v(dout0_17) AT=930.025n

* CHECK dout0_18 Vdout0_18ck185 = 0 time = 930
.meas tran vdout0_18ck185 FIND v(dout0_18) AT=930.025n

* CHECK dout0_19 Vdout0_19ck185 = 1.1 time = 930
.meas tran vdout0_19ck185 FIND v(dout0_19) AT=930.025n

* CHECK dout0_20 Vdout0_20ck185 = 0 time = 930
.meas tran vdout0_20ck185 FIND v(dout0_20) AT=930.025n

* CHECK dout0_21 Vdout0_21ck185 = 1.1 time = 930
.meas tran vdout0_21ck185 FIND v(dout0_21) AT=930.025n

* CHECK dout0_22 Vdout0_22ck185 = 0 time = 930
.meas tran vdout0_22ck185 FIND v(dout0_22) AT=930.025n

* CHECK dout0_23 Vdout0_23ck185 = 1.1 time = 930
.meas tran vdout0_23ck185 FIND v(dout0_23) AT=930.025n

* CHECK dout0_24 Vdout0_24ck185 = 0 time = 930
.meas tran vdout0_24ck185 FIND v(dout0_24) AT=930.025n

* CHECK dout0_25 Vdout0_25ck185 = 1.1 time = 930
.meas tran vdout0_25ck185 FIND v(dout0_25) AT=930.025n

* CHECK dout0_26 Vdout0_26ck185 = 0 time = 930
.meas tran vdout0_26ck185 FIND v(dout0_26) AT=930.025n

* CHECK dout0_27 Vdout0_27ck185 = 1.1 time = 930
.meas tran vdout0_27ck185 FIND v(dout0_27) AT=930.025n

* CHECK dout0_28 Vdout0_28ck185 = 1.1 time = 930
.meas tran vdout0_28ck185 FIND v(dout0_28) AT=930.025n

* CHECK dout0_29 Vdout0_29ck185 = 0 time = 930
.meas tran vdout0_29ck185 FIND v(dout0_29) AT=930.025n

* CHECK dout0_30 Vdout0_30ck185 = 1.1 time = 930
.meas tran vdout0_30ck185 FIND v(dout0_30) AT=930.025n

* CHECK dout0_31 Vdout0_31ck185 = 1.1 time = 930
.meas tran vdout0_31ck185 FIND v(dout0_31) AT=930.025n

* CHECK dout0_0 Vdout0_0ck186 = 1.1 time = 935
.meas tran vdout0_0ck186 FIND v(dout0_0) AT=935.025n

* CHECK dout0_1 Vdout0_1ck186 = 0 time = 935
.meas tran vdout0_1ck186 FIND v(dout0_1) AT=935.025n

* CHECK dout0_2 Vdout0_2ck186 = 0 time = 935
.meas tran vdout0_2ck186 FIND v(dout0_2) AT=935.025n

* CHECK dout0_3 Vdout0_3ck186 = 1.1 time = 935
.meas tran vdout0_3ck186 FIND v(dout0_3) AT=935.025n

* CHECK dout0_4 Vdout0_4ck186 = 0 time = 935
.meas tran vdout0_4ck186 FIND v(dout0_4) AT=935.025n

* CHECK dout0_5 Vdout0_5ck186 = 0 time = 935
.meas tran vdout0_5ck186 FIND v(dout0_5) AT=935.025n

* CHECK dout0_6 Vdout0_6ck186 = 1.1 time = 935
.meas tran vdout0_6ck186 FIND v(dout0_6) AT=935.025n

* CHECK dout0_7 Vdout0_7ck186 = 0 time = 935
.meas tran vdout0_7ck186 FIND v(dout0_7) AT=935.025n

* CHECK dout0_8 Vdout0_8ck186 = 1.1 time = 935
.meas tran vdout0_8ck186 FIND v(dout0_8) AT=935.025n

* CHECK dout0_9 Vdout0_9ck186 = 0 time = 935
.meas tran vdout0_9ck186 FIND v(dout0_9) AT=935.025n

* CHECK dout0_10 Vdout0_10ck186 = 1.1 time = 935
.meas tran vdout0_10ck186 FIND v(dout0_10) AT=935.025n

* CHECK dout0_11 Vdout0_11ck186 = 1.1 time = 935
.meas tran vdout0_11ck186 FIND v(dout0_11) AT=935.025n

* CHECK dout0_12 Vdout0_12ck186 = 1.1 time = 935
.meas tran vdout0_12ck186 FIND v(dout0_12) AT=935.025n

* CHECK dout0_13 Vdout0_13ck186 = 1.1 time = 935
.meas tran vdout0_13ck186 FIND v(dout0_13) AT=935.025n

* CHECK dout0_14 Vdout0_14ck186 = 1.1 time = 935
.meas tran vdout0_14ck186 FIND v(dout0_14) AT=935.025n

* CHECK dout0_15 Vdout0_15ck186 = 0 time = 935
.meas tran vdout0_15ck186 FIND v(dout0_15) AT=935.025n

* CHECK dout0_16 Vdout0_16ck186 = 1.1 time = 935
.meas tran vdout0_16ck186 FIND v(dout0_16) AT=935.025n

* CHECK dout0_17 Vdout0_17ck186 = 1.1 time = 935
.meas tran vdout0_17ck186 FIND v(dout0_17) AT=935.025n

* CHECK dout0_18 Vdout0_18ck186 = 1.1 time = 935
.meas tran vdout0_18ck186 FIND v(dout0_18) AT=935.025n

* CHECK dout0_19 Vdout0_19ck186 = 1.1 time = 935
.meas tran vdout0_19ck186 FIND v(dout0_19) AT=935.025n

* CHECK dout0_20 Vdout0_20ck186 = 0 time = 935
.meas tran vdout0_20ck186 FIND v(dout0_20) AT=935.025n

* CHECK dout0_21 Vdout0_21ck186 = 0 time = 935
.meas tran vdout0_21ck186 FIND v(dout0_21) AT=935.025n

* CHECK dout0_22 Vdout0_22ck186 = 0 time = 935
.meas tran vdout0_22ck186 FIND v(dout0_22) AT=935.025n

* CHECK dout0_23 Vdout0_23ck186 = 1.1 time = 935
.meas tran vdout0_23ck186 FIND v(dout0_23) AT=935.025n

* CHECK dout0_24 Vdout0_24ck186 = 0 time = 935
.meas tran vdout0_24ck186 FIND v(dout0_24) AT=935.025n

* CHECK dout0_25 Vdout0_25ck186 = 0 time = 935
.meas tran vdout0_25ck186 FIND v(dout0_25) AT=935.025n

* CHECK dout0_26 Vdout0_26ck186 = 1.1 time = 935
.meas tran vdout0_26ck186 FIND v(dout0_26) AT=935.025n

* CHECK dout0_27 Vdout0_27ck186 = 0 time = 935
.meas tran vdout0_27ck186 FIND v(dout0_27) AT=935.025n

* CHECK dout0_28 Vdout0_28ck186 = 0 time = 935
.meas tran vdout0_28ck186 FIND v(dout0_28) AT=935.025n

* CHECK dout0_29 Vdout0_29ck186 = 1.1 time = 935
.meas tran vdout0_29ck186 FIND v(dout0_29) AT=935.025n

* CHECK dout0_30 Vdout0_30ck186 = 1.1 time = 935
.meas tran vdout0_30ck186 FIND v(dout0_30) AT=935.025n

* CHECK dout0_31 Vdout0_31ck186 = 0 time = 935
.meas tran vdout0_31ck186 FIND v(dout0_31) AT=935.025n

* CHECK dout0_0 Vdout0_0ck187 = 0 time = 940
.meas tran vdout0_0ck187 FIND v(dout0_0) AT=940.025n

* CHECK dout0_1 Vdout0_1ck187 = 0 time = 940
.meas tran vdout0_1ck187 FIND v(dout0_1) AT=940.025n

* CHECK dout0_2 Vdout0_2ck187 = 0 time = 940
.meas tran vdout0_2ck187 FIND v(dout0_2) AT=940.025n

* CHECK dout0_3 Vdout0_3ck187 = 1.1 time = 940
.meas tran vdout0_3ck187 FIND v(dout0_3) AT=940.025n

* CHECK dout0_4 Vdout0_4ck187 = 1.1 time = 940
.meas tran vdout0_4ck187 FIND v(dout0_4) AT=940.025n

* CHECK dout0_5 Vdout0_5ck187 = 0 time = 940
.meas tran vdout0_5ck187 FIND v(dout0_5) AT=940.025n

* CHECK dout0_6 Vdout0_6ck187 = 0 time = 940
.meas tran vdout0_6ck187 FIND v(dout0_6) AT=940.025n

* CHECK dout0_7 Vdout0_7ck187 = 1.1 time = 940
.meas tran vdout0_7ck187 FIND v(dout0_7) AT=940.025n

* CHECK dout0_8 Vdout0_8ck187 = 0 time = 940
.meas tran vdout0_8ck187 FIND v(dout0_8) AT=940.025n

* CHECK dout0_9 Vdout0_9ck187 = 0 time = 940
.meas tran vdout0_9ck187 FIND v(dout0_9) AT=940.025n

* CHECK dout0_10 Vdout0_10ck187 = 1.1 time = 940
.meas tran vdout0_10ck187 FIND v(dout0_10) AT=940.025n

* CHECK dout0_11 Vdout0_11ck187 = 1.1 time = 940
.meas tran vdout0_11ck187 FIND v(dout0_11) AT=940.025n

* CHECK dout0_12 Vdout0_12ck187 = 1.1 time = 940
.meas tran vdout0_12ck187 FIND v(dout0_12) AT=940.025n

* CHECK dout0_13 Vdout0_13ck187 = 1.1 time = 940
.meas tran vdout0_13ck187 FIND v(dout0_13) AT=940.025n

* CHECK dout0_14 Vdout0_14ck187 = 0 time = 940
.meas tran vdout0_14ck187 FIND v(dout0_14) AT=940.025n

* CHECK dout0_15 Vdout0_15ck187 = 1.1 time = 940
.meas tran vdout0_15ck187 FIND v(dout0_15) AT=940.025n

* CHECK dout0_16 Vdout0_16ck187 = 0 time = 940
.meas tran vdout0_16ck187 FIND v(dout0_16) AT=940.025n

* CHECK dout0_17 Vdout0_17ck187 = 1.1 time = 940
.meas tran vdout0_17ck187 FIND v(dout0_17) AT=940.025n

* CHECK dout0_18 Vdout0_18ck187 = 0 time = 940
.meas tran vdout0_18ck187 FIND v(dout0_18) AT=940.025n

* CHECK dout0_19 Vdout0_19ck187 = 1.1 time = 940
.meas tran vdout0_19ck187 FIND v(dout0_19) AT=940.025n

* CHECK dout0_20 Vdout0_20ck187 = 1.1 time = 940
.meas tran vdout0_20ck187 FIND v(dout0_20) AT=940.025n

* CHECK dout0_21 Vdout0_21ck187 = 1.1 time = 940
.meas tran vdout0_21ck187 FIND v(dout0_21) AT=940.025n

* CHECK dout0_22 Vdout0_22ck187 = 0 time = 940
.meas tran vdout0_22ck187 FIND v(dout0_22) AT=940.025n

* CHECK dout0_23 Vdout0_23ck187 = 0 time = 940
.meas tran vdout0_23ck187 FIND v(dout0_23) AT=940.025n

* CHECK dout0_24 Vdout0_24ck187 = 0 time = 940
.meas tran vdout0_24ck187 FIND v(dout0_24) AT=940.025n

* CHECK dout0_25 Vdout0_25ck187 = 1.1 time = 940
.meas tran vdout0_25ck187 FIND v(dout0_25) AT=940.025n

* CHECK dout0_26 Vdout0_26ck187 = 1.1 time = 940
.meas tran vdout0_26ck187 FIND v(dout0_26) AT=940.025n

* CHECK dout0_27 Vdout0_27ck187 = 0 time = 940
.meas tran vdout0_27ck187 FIND v(dout0_27) AT=940.025n

* CHECK dout0_28 Vdout0_28ck187 = 1.1 time = 940
.meas tran vdout0_28ck187 FIND v(dout0_28) AT=940.025n

* CHECK dout0_29 Vdout0_29ck187 = 1.1 time = 940
.meas tran vdout0_29ck187 FIND v(dout0_29) AT=940.025n

* CHECK dout0_30 Vdout0_30ck187 = 0 time = 940
.meas tran vdout0_30ck187 FIND v(dout0_30) AT=940.025n

* CHECK dout0_31 Vdout0_31ck187 = 0 time = 940
.meas tran vdout0_31ck187 FIND v(dout0_31) AT=940.025n

* CHECK dout0_0 Vdout0_0ck188 = 0 time = 945
.meas tran vdout0_0ck188 FIND v(dout0_0) AT=945.025n

* CHECK dout0_1 Vdout0_1ck188 = 0 time = 945
.meas tran vdout0_1ck188 FIND v(dout0_1) AT=945.025n

* CHECK dout0_2 Vdout0_2ck188 = 1.1 time = 945
.meas tran vdout0_2ck188 FIND v(dout0_2) AT=945.025n

* CHECK dout0_3 Vdout0_3ck188 = 0 time = 945
.meas tran vdout0_3ck188 FIND v(dout0_3) AT=945.025n

* CHECK dout0_4 Vdout0_4ck188 = 1.1 time = 945
.meas tran vdout0_4ck188 FIND v(dout0_4) AT=945.025n

* CHECK dout0_5 Vdout0_5ck188 = 0 time = 945
.meas tran vdout0_5ck188 FIND v(dout0_5) AT=945.025n

* CHECK dout0_6 Vdout0_6ck188 = 1.1 time = 945
.meas tran vdout0_6ck188 FIND v(dout0_6) AT=945.025n

* CHECK dout0_7 Vdout0_7ck188 = 0 time = 945
.meas tran vdout0_7ck188 FIND v(dout0_7) AT=945.025n

* CHECK dout0_8 Vdout0_8ck188 = 0 time = 945
.meas tran vdout0_8ck188 FIND v(dout0_8) AT=945.025n

* CHECK dout0_9 Vdout0_9ck188 = 1.1 time = 945
.meas tran vdout0_9ck188 FIND v(dout0_9) AT=945.025n

* CHECK dout0_10 Vdout0_10ck188 = 1.1 time = 945
.meas tran vdout0_10ck188 FIND v(dout0_10) AT=945.025n

* CHECK dout0_11 Vdout0_11ck188 = 1.1 time = 945
.meas tran vdout0_11ck188 FIND v(dout0_11) AT=945.025n

* CHECK dout0_12 Vdout0_12ck188 = 0 time = 945
.meas tran vdout0_12ck188 FIND v(dout0_12) AT=945.025n

* CHECK dout0_13 Vdout0_13ck188 = 1.1 time = 945
.meas tran vdout0_13ck188 FIND v(dout0_13) AT=945.025n

* CHECK dout0_14 Vdout0_14ck188 = 0 time = 945
.meas tran vdout0_14ck188 FIND v(dout0_14) AT=945.025n

* CHECK dout0_15 Vdout0_15ck188 = 0 time = 945
.meas tran vdout0_15ck188 FIND v(dout0_15) AT=945.025n

* CHECK dout0_16 Vdout0_16ck188 = 1.1 time = 945
.meas tran vdout0_16ck188 FIND v(dout0_16) AT=945.025n

* CHECK dout0_17 Vdout0_17ck188 = 1.1 time = 945
.meas tran vdout0_17ck188 FIND v(dout0_17) AT=945.025n

* CHECK dout0_18 Vdout0_18ck188 = 1.1 time = 945
.meas tran vdout0_18ck188 FIND v(dout0_18) AT=945.025n

* CHECK dout0_19 Vdout0_19ck188 = 0 time = 945
.meas tran vdout0_19ck188 FIND v(dout0_19) AT=945.025n

* CHECK dout0_20 Vdout0_20ck188 = 1.1 time = 945
.meas tran vdout0_20ck188 FIND v(dout0_20) AT=945.025n

* CHECK dout0_21 Vdout0_21ck188 = 1.1 time = 945
.meas tran vdout0_21ck188 FIND v(dout0_21) AT=945.025n

* CHECK dout0_22 Vdout0_22ck188 = 0 time = 945
.meas tran vdout0_22ck188 FIND v(dout0_22) AT=945.025n

* CHECK dout0_23 Vdout0_23ck188 = 0 time = 945
.meas tran vdout0_23ck188 FIND v(dout0_23) AT=945.025n

* CHECK dout0_24 Vdout0_24ck188 = 0 time = 945
.meas tran vdout0_24ck188 FIND v(dout0_24) AT=945.025n

* CHECK dout0_25 Vdout0_25ck188 = 1.1 time = 945
.meas tran vdout0_25ck188 FIND v(dout0_25) AT=945.025n

* CHECK dout0_26 Vdout0_26ck188 = 1.1 time = 945
.meas tran vdout0_26ck188 FIND v(dout0_26) AT=945.025n

* CHECK dout0_27 Vdout0_27ck188 = 0 time = 945
.meas tran vdout0_27ck188 FIND v(dout0_27) AT=945.025n

* CHECK dout0_28 Vdout0_28ck188 = 0 time = 945
.meas tran vdout0_28ck188 FIND v(dout0_28) AT=945.025n

* CHECK dout0_29 Vdout0_29ck188 = 0 time = 945
.meas tran vdout0_29ck188 FIND v(dout0_29) AT=945.025n

* CHECK dout0_30 Vdout0_30ck188 = 0 time = 945
.meas tran vdout0_30ck188 FIND v(dout0_30) AT=945.025n

* CHECK dout0_31 Vdout0_31ck188 = 1.1 time = 945
.meas tran vdout0_31ck188 FIND v(dout0_31) AT=945.025n

* CHECK dout0_0 Vdout0_0ck193 = 1.1 time = 970
.meas tran vdout0_0ck193 FIND v(dout0_0) AT=970.025n

* CHECK dout0_1 Vdout0_1ck193 = 0 time = 970
.meas tran vdout0_1ck193 FIND v(dout0_1) AT=970.025n

* CHECK dout0_2 Vdout0_2ck193 = 0 time = 970
.meas tran vdout0_2ck193 FIND v(dout0_2) AT=970.025n

* CHECK dout0_3 Vdout0_3ck193 = 0 time = 970
.meas tran vdout0_3ck193 FIND v(dout0_3) AT=970.025n

* CHECK dout0_4 Vdout0_4ck193 = 0 time = 970
.meas tran vdout0_4ck193 FIND v(dout0_4) AT=970.025n

* CHECK dout0_5 Vdout0_5ck193 = 0 time = 970
.meas tran vdout0_5ck193 FIND v(dout0_5) AT=970.025n

* CHECK dout0_6 Vdout0_6ck193 = 0 time = 970
.meas tran vdout0_6ck193 FIND v(dout0_6) AT=970.025n

* CHECK dout0_7 Vdout0_7ck193 = 0 time = 970
.meas tran vdout0_7ck193 FIND v(dout0_7) AT=970.025n

* CHECK dout0_8 Vdout0_8ck193 = 1.1 time = 970
.meas tran vdout0_8ck193 FIND v(dout0_8) AT=970.025n

* CHECK dout0_9 Vdout0_9ck193 = 0 time = 970
.meas tran vdout0_9ck193 FIND v(dout0_9) AT=970.025n

* CHECK dout0_10 Vdout0_10ck193 = 1.1 time = 970
.meas tran vdout0_10ck193 FIND v(dout0_10) AT=970.025n

* CHECK dout0_11 Vdout0_11ck193 = 0 time = 970
.meas tran vdout0_11ck193 FIND v(dout0_11) AT=970.025n

* CHECK dout0_12 Vdout0_12ck193 = 1.1 time = 970
.meas tran vdout0_12ck193 FIND v(dout0_12) AT=970.025n

* CHECK dout0_13 Vdout0_13ck193 = 1.1 time = 970
.meas tran vdout0_13ck193 FIND v(dout0_13) AT=970.025n

* CHECK dout0_14 Vdout0_14ck193 = 0 time = 970
.meas tran vdout0_14ck193 FIND v(dout0_14) AT=970.025n

* CHECK dout0_15 Vdout0_15ck193 = 0 time = 970
.meas tran vdout0_15ck193 FIND v(dout0_15) AT=970.025n

* CHECK dout0_16 Vdout0_16ck193 = 0 time = 970
.meas tran vdout0_16ck193 FIND v(dout0_16) AT=970.025n

* CHECK dout0_17 Vdout0_17ck193 = 1.1 time = 970
.meas tran vdout0_17ck193 FIND v(dout0_17) AT=970.025n

* CHECK dout0_18 Vdout0_18ck193 = 1.1 time = 970
.meas tran vdout0_18ck193 FIND v(dout0_18) AT=970.025n

* CHECK dout0_19 Vdout0_19ck193 = 0 time = 970
.meas tran vdout0_19ck193 FIND v(dout0_19) AT=970.025n

* CHECK dout0_20 Vdout0_20ck193 = 0 time = 970
.meas tran vdout0_20ck193 FIND v(dout0_20) AT=970.025n

* CHECK dout0_21 Vdout0_21ck193 = 0 time = 970
.meas tran vdout0_21ck193 FIND v(dout0_21) AT=970.025n

* CHECK dout0_22 Vdout0_22ck193 = 1.1 time = 970
.meas tran vdout0_22ck193 FIND v(dout0_22) AT=970.025n

* CHECK dout0_23 Vdout0_23ck193 = 1.1 time = 970
.meas tran vdout0_23ck193 FIND v(dout0_23) AT=970.025n

* CHECK dout0_24 Vdout0_24ck193 = 0 time = 970
.meas tran vdout0_24ck193 FIND v(dout0_24) AT=970.025n

* CHECK dout0_25 Vdout0_25ck193 = 0 time = 970
.meas tran vdout0_25ck193 FIND v(dout0_25) AT=970.025n

* CHECK dout0_26 Vdout0_26ck193 = 1.1 time = 970
.meas tran vdout0_26ck193 FIND v(dout0_26) AT=970.025n

* CHECK dout0_27 Vdout0_27ck193 = 1.1 time = 970
.meas tran vdout0_27ck193 FIND v(dout0_27) AT=970.025n

* CHECK dout0_28 Vdout0_28ck193 = 1.1 time = 970
.meas tran vdout0_28ck193 FIND v(dout0_28) AT=970.025n

* CHECK dout0_29 Vdout0_29ck193 = 1.1 time = 970
.meas tran vdout0_29ck193 FIND v(dout0_29) AT=970.025n

* CHECK dout0_30 Vdout0_30ck193 = 1.1 time = 970
.meas tran vdout0_30ck193 FIND v(dout0_30) AT=970.025n

* CHECK dout0_31 Vdout0_31ck193 = 1.1 time = 970
.meas tran vdout0_31ck193 FIND v(dout0_31) AT=970.025n

* CHECK dout0_0 Vdout0_0ck194 = 1.1 time = 975
.meas tran vdout0_0ck194 FIND v(dout0_0) AT=975.025n

* CHECK dout0_1 Vdout0_1ck194 = 0 time = 975
.meas tran vdout0_1ck194 FIND v(dout0_1) AT=975.025n

* CHECK dout0_2 Vdout0_2ck194 = 1.1 time = 975
.meas tran vdout0_2ck194 FIND v(dout0_2) AT=975.025n

* CHECK dout0_3 Vdout0_3ck194 = 1.1 time = 975
.meas tran vdout0_3ck194 FIND v(dout0_3) AT=975.025n

* CHECK dout0_4 Vdout0_4ck194 = 0 time = 975
.meas tran vdout0_4ck194 FIND v(dout0_4) AT=975.025n

* CHECK dout0_5 Vdout0_5ck194 = 0 time = 975
.meas tran vdout0_5ck194 FIND v(dout0_5) AT=975.025n

* CHECK dout0_6 Vdout0_6ck194 = 1.1 time = 975
.meas tran vdout0_6ck194 FIND v(dout0_6) AT=975.025n

* CHECK dout0_7 Vdout0_7ck194 = 0 time = 975
.meas tran vdout0_7ck194 FIND v(dout0_7) AT=975.025n

* CHECK dout0_8 Vdout0_8ck194 = 1.1 time = 975
.meas tran vdout0_8ck194 FIND v(dout0_8) AT=975.025n

* CHECK dout0_9 Vdout0_9ck194 = 0 time = 975
.meas tran vdout0_9ck194 FIND v(dout0_9) AT=975.025n

* CHECK dout0_10 Vdout0_10ck194 = 1.1 time = 975
.meas tran vdout0_10ck194 FIND v(dout0_10) AT=975.025n

* CHECK dout0_11 Vdout0_11ck194 = 1.1 time = 975
.meas tran vdout0_11ck194 FIND v(dout0_11) AT=975.025n

* CHECK dout0_12 Vdout0_12ck194 = 0 time = 975
.meas tran vdout0_12ck194 FIND v(dout0_12) AT=975.025n

* CHECK dout0_13 Vdout0_13ck194 = 1.1 time = 975
.meas tran vdout0_13ck194 FIND v(dout0_13) AT=975.025n

* CHECK dout0_14 Vdout0_14ck194 = 0 time = 975
.meas tran vdout0_14ck194 FIND v(dout0_14) AT=975.025n

* CHECK dout0_15 Vdout0_15ck194 = 1.1 time = 975
.meas tran vdout0_15ck194 FIND v(dout0_15) AT=975.025n

* CHECK dout0_16 Vdout0_16ck194 = 1.1 time = 975
.meas tran vdout0_16ck194 FIND v(dout0_16) AT=975.025n

* CHECK dout0_17 Vdout0_17ck194 = 1.1 time = 975
.meas tran vdout0_17ck194 FIND v(dout0_17) AT=975.025n

* CHECK dout0_18 Vdout0_18ck194 = 0 time = 975
.meas tran vdout0_18ck194 FIND v(dout0_18) AT=975.025n

* CHECK dout0_19 Vdout0_19ck194 = 0 time = 975
.meas tran vdout0_19ck194 FIND v(dout0_19) AT=975.025n

* CHECK dout0_20 Vdout0_20ck194 = 0 time = 975
.meas tran vdout0_20ck194 FIND v(dout0_20) AT=975.025n

* CHECK dout0_21 Vdout0_21ck194 = 0 time = 975
.meas tran vdout0_21ck194 FIND v(dout0_21) AT=975.025n

* CHECK dout0_22 Vdout0_22ck194 = 0 time = 975
.meas tran vdout0_22ck194 FIND v(dout0_22) AT=975.025n

* CHECK dout0_23 Vdout0_23ck194 = 1.1 time = 975
.meas tran vdout0_23ck194 FIND v(dout0_23) AT=975.025n

* CHECK dout0_24 Vdout0_24ck194 = 0 time = 975
.meas tran vdout0_24ck194 FIND v(dout0_24) AT=975.025n

* CHECK dout0_25 Vdout0_25ck194 = 0 time = 975
.meas tran vdout0_25ck194 FIND v(dout0_25) AT=975.025n

* CHECK dout0_26 Vdout0_26ck194 = 0 time = 975
.meas tran vdout0_26ck194 FIND v(dout0_26) AT=975.025n

* CHECK dout0_27 Vdout0_27ck194 = 1.1 time = 975
.meas tran vdout0_27ck194 FIND v(dout0_27) AT=975.025n

* CHECK dout0_28 Vdout0_28ck194 = 1.1 time = 975
.meas tran vdout0_28ck194 FIND v(dout0_28) AT=975.025n

* CHECK dout0_29 Vdout0_29ck194 = 1.1 time = 975
.meas tran vdout0_29ck194 FIND v(dout0_29) AT=975.025n

* CHECK dout0_30 Vdout0_30ck194 = 1.1 time = 975
.meas tran vdout0_30ck194 FIND v(dout0_30) AT=975.025n

* CHECK dout0_31 Vdout0_31ck194 = 0 time = 975
.meas tran vdout0_31ck194 FIND v(dout0_31) AT=975.025n

* CHECK dout0_0 Vdout0_0ck199 = 1.1 time = 1000
.meas tran vdout0_0ck199 FIND v(dout0_0) AT=1000.025n

* CHECK dout0_1 Vdout0_1ck199 = 0 time = 1000
.meas tran vdout0_1ck199 FIND v(dout0_1) AT=1000.025n

* CHECK dout0_2 Vdout0_2ck199 = 1.1 time = 1000
.meas tran vdout0_2ck199 FIND v(dout0_2) AT=1000.025n

* CHECK dout0_3 Vdout0_3ck199 = 0 time = 1000
.meas tran vdout0_3ck199 FIND v(dout0_3) AT=1000.025n

* CHECK dout0_4 Vdout0_4ck199 = 0 time = 1000
.meas tran vdout0_4ck199 FIND v(dout0_4) AT=1000.025n

* CHECK dout0_5 Vdout0_5ck199 = 0 time = 1000
.meas tran vdout0_5ck199 FIND v(dout0_5) AT=1000.025n

* CHECK dout0_6 Vdout0_6ck199 = 1.1 time = 1000
.meas tran vdout0_6ck199 FIND v(dout0_6) AT=1000.025n

* CHECK dout0_7 Vdout0_7ck199 = 1.1 time = 1000
.meas tran vdout0_7ck199 FIND v(dout0_7) AT=1000.025n

* CHECK dout0_8 Vdout0_8ck199 = 0 time = 1000
.meas tran vdout0_8ck199 FIND v(dout0_8) AT=1000.025n

* CHECK dout0_9 Vdout0_9ck199 = 1.1 time = 1000
.meas tran vdout0_9ck199 FIND v(dout0_9) AT=1000.025n

* CHECK dout0_10 Vdout0_10ck199 = 1.1 time = 1000
.meas tran vdout0_10ck199 FIND v(dout0_10) AT=1000.025n

* CHECK dout0_11 Vdout0_11ck199 = 0 time = 1000
.meas tran vdout0_11ck199 FIND v(dout0_11) AT=1000.025n

* CHECK dout0_12 Vdout0_12ck199 = 0 time = 1000
.meas tran vdout0_12ck199 FIND v(dout0_12) AT=1000.025n

* CHECK dout0_13 Vdout0_13ck199 = 0 time = 1000
.meas tran vdout0_13ck199 FIND v(dout0_13) AT=1000.025n

* CHECK dout0_14 Vdout0_14ck199 = 0 time = 1000
.meas tran vdout0_14ck199 FIND v(dout0_14) AT=1000.025n

* CHECK dout0_15 Vdout0_15ck199 = 0 time = 1000
.meas tran vdout0_15ck199 FIND v(dout0_15) AT=1000.025n

* CHECK dout0_16 Vdout0_16ck199 = 1.1 time = 1000
.meas tran vdout0_16ck199 FIND v(dout0_16) AT=1000.025n

* CHECK dout0_17 Vdout0_17ck199 = 0 time = 1000
.meas tran vdout0_17ck199 FIND v(dout0_17) AT=1000.025n

* CHECK dout0_18 Vdout0_18ck199 = 0 time = 1000
.meas tran vdout0_18ck199 FIND v(dout0_18) AT=1000.025n

* CHECK dout0_19 Vdout0_19ck199 = 0 time = 1000
.meas tran vdout0_19ck199 FIND v(dout0_19) AT=1000.025n

* CHECK dout0_20 Vdout0_20ck199 = 0 time = 1000
.meas tran vdout0_20ck199 FIND v(dout0_20) AT=1000.025n

* CHECK dout0_21 Vdout0_21ck199 = 1.1 time = 1000
.meas tran vdout0_21ck199 FIND v(dout0_21) AT=1000.025n

* CHECK dout0_22 Vdout0_22ck199 = 0 time = 1000
.meas tran vdout0_22ck199 FIND v(dout0_22) AT=1000.025n

* CHECK dout0_23 Vdout0_23ck199 = 0 time = 1000
.meas tran vdout0_23ck199 FIND v(dout0_23) AT=1000.025n

* CHECK dout0_24 Vdout0_24ck199 = 0 time = 1000
.meas tran vdout0_24ck199 FIND v(dout0_24) AT=1000.025n

* CHECK dout0_25 Vdout0_25ck199 = 1.1 time = 1000
.meas tran vdout0_25ck199 FIND v(dout0_25) AT=1000.025n

* CHECK dout0_26 Vdout0_26ck199 = 0 time = 1000
.meas tran vdout0_26ck199 FIND v(dout0_26) AT=1000.025n

* CHECK dout0_27 Vdout0_27ck199 = 1.1 time = 1000
.meas tran vdout0_27ck199 FIND v(dout0_27) AT=1000.025n

* CHECK dout0_28 Vdout0_28ck199 = 1.1 time = 1000
.meas tran vdout0_28ck199 FIND v(dout0_28) AT=1000.025n

* CHECK dout0_29 Vdout0_29ck199 = 0 time = 1000
.meas tran vdout0_29ck199 FIND v(dout0_29) AT=1000.025n

* CHECK dout0_30 Vdout0_30ck199 = 0 time = 1000
.meas tran vdout0_30ck199 FIND v(dout0_30) AT=1000.025n

* CHECK dout0_31 Vdout0_31ck199 = 1.1 time = 1000
.meas tran vdout0_31ck199 FIND v(dout0_31) AT=1000.025n

* CHECK dout0_0 Vdout0_0ck201 = 1.1 time = 1010
.meas tran vdout0_0ck201 FIND v(dout0_0) AT=1010.025n

* CHECK dout0_1 Vdout0_1ck201 = 0 time = 1010
.meas tran vdout0_1ck201 FIND v(dout0_1) AT=1010.025n

* CHECK dout0_2 Vdout0_2ck201 = 0 time = 1010
.meas tran vdout0_2ck201 FIND v(dout0_2) AT=1010.025n

* CHECK dout0_3 Vdout0_3ck201 = 0 time = 1010
.meas tran vdout0_3ck201 FIND v(dout0_3) AT=1010.025n

* CHECK dout0_4 Vdout0_4ck201 = 0 time = 1010
.meas tran vdout0_4ck201 FIND v(dout0_4) AT=1010.025n

* CHECK dout0_5 Vdout0_5ck201 = 0 time = 1010
.meas tran vdout0_5ck201 FIND v(dout0_5) AT=1010.025n

* CHECK dout0_6 Vdout0_6ck201 = 0 time = 1010
.meas tran vdout0_6ck201 FIND v(dout0_6) AT=1010.025n

* CHECK dout0_7 Vdout0_7ck201 = 0 time = 1010
.meas tran vdout0_7ck201 FIND v(dout0_7) AT=1010.025n

* CHECK dout0_8 Vdout0_8ck201 = 1.1 time = 1010
.meas tran vdout0_8ck201 FIND v(dout0_8) AT=1010.025n

* CHECK dout0_9 Vdout0_9ck201 = 0 time = 1010
.meas tran vdout0_9ck201 FIND v(dout0_9) AT=1010.025n

* CHECK dout0_10 Vdout0_10ck201 = 1.1 time = 1010
.meas tran vdout0_10ck201 FIND v(dout0_10) AT=1010.025n

* CHECK dout0_11 Vdout0_11ck201 = 0 time = 1010
.meas tran vdout0_11ck201 FIND v(dout0_11) AT=1010.025n

* CHECK dout0_12 Vdout0_12ck201 = 1.1 time = 1010
.meas tran vdout0_12ck201 FIND v(dout0_12) AT=1010.025n

* CHECK dout0_13 Vdout0_13ck201 = 1.1 time = 1010
.meas tran vdout0_13ck201 FIND v(dout0_13) AT=1010.025n

* CHECK dout0_14 Vdout0_14ck201 = 0 time = 1010
.meas tran vdout0_14ck201 FIND v(dout0_14) AT=1010.025n

* CHECK dout0_15 Vdout0_15ck201 = 0 time = 1010
.meas tran vdout0_15ck201 FIND v(dout0_15) AT=1010.025n

* CHECK dout0_16 Vdout0_16ck201 = 0 time = 1010
.meas tran vdout0_16ck201 FIND v(dout0_16) AT=1010.025n

* CHECK dout0_17 Vdout0_17ck201 = 1.1 time = 1010
.meas tran vdout0_17ck201 FIND v(dout0_17) AT=1010.025n

* CHECK dout0_18 Vdout0_18ck201 = 1.1 time = 1010
.meas tran vdout0_18ck201 FIND v(dout0_18) AT=1010.025n

* CHECK dout0_19 Vdout0_19ck201 = 0 time = 1010
.meas tran vdout0_19ck201 FIND v(dout0_19) AT=1010.025n

* CHECK dout0_20 Vdout0_20ck201 = 0 time = 1010
.meas tran vdout0_20ck201 FIND v(dout0_20) AT=1010.025n

* CHECK dout0_21 Vdout0_21ck201 = 0 time = 1010
.meas tran vdout0_21ck201 FIND v(dout0_21) AT=1010.025n

* CHECK dout0_22 Vdout0_22ck201 = 1.1 time = 1010
.meas tran vdout0_22ck201 FIND v(dout0_22) AT=1010.025n

* CHECK dout0_23 Vdout0_23ck201 = 1.1 time = 1010
.meas tran vdout0_23ck201 FIND v(dout0_23) AT=1010.025n

* CHECK dout0_24 Vdout0_24ck201 = 0 time = 1010
.meas tran vdout0_24ck201 FIND v(dout0_24) AT=1010.025n

* CHECK dout0_25 Vdout0_25ck201 = 0 time = 1010
.meas tran vdout0_25ck201 FIND v(dout0_25) AT=1010.025n

* CHECK dout0_26 Vdout0_26ck201 = 1.1 time = 1010
.meas tran vdout0_26ck201 FIND v(dout0_26) AT=1010.025n

* CHECK dout0_27 Vdout0_27ck201 = 1.1 time = 1010
.meas tran vdout0_27ck201 FIND v(dout0_27) AT=1010.025n

* CHECK dout0_28 Vdout0_28ck201 = 1.1 time = 1010
.meas tran vdout0_28ck201 FIND v(dout0_28) AT=1010.025n

* CHECK dout0_29 Vdout0_29ck201 = 1.1 time = 1010
.meas tran vdout0_29ck201 FIND v(dout0_29) AT=1010.025n

* CHECK dout0_30 Vdout0_30ck201 = 1.1 time = 1010
.meas tran vdout0_30ck201 FIND v(dout0_30) AT=1010.025n

* CHECK dout0_31 Vdout0_31ck201 = 1.1 time = 1010
.meas tran vdout0_31ck201 FIND v(dout0_31) AT=1010.025n

* CHECK dout0_0 Vdout0_0ck202 = 1.1 time = 1015
.meas tran vdout0_0ck202 FIND v(dout0_0) AT=1015.025n

* CHECK dout0_1 Vdout0_1ck202 = 0 time = 1015
.meas tran vdout0_1ck202 FIND v(dout0_1) AT=1015.025n

* CHECK dout0_2 Vdout0_2ck202 = 0 time = 1015
.meas tran vdout0_2ck202 FIND v(dout0_2) AT=1015.025n

* CHECK dout0_3 Vdout0_3ck202 = 0 time = 1015
.meas tran vdout0_3ck202 FIND v(dout0_3) AT=1015.025n

* CHECK dout0_4 Vdout0_4ck202 = 0 time = 1015
.meas tran vdout0_4ck202 FIND v(dout0_4) AT=1015.025n

* CHECK dout0_5 Vdout0_5ck202 = 0 time = 1015
.meas tran vdout0_5ck202 FIND v(dout0_5) AT=1015.025n

* CHECK dout0_6 Vdout0_6ck202 = 0 time = 1015
.meas tran vdout0_6ck202 FIND v(dout0_6) AT=1015.025n

* CHECK dout0_7 Vdout0_7ck202 = 0 time = 1015
.meas tran vdout0_7ck202 FIND v(dout0_7) AT=1015.025n

* CHECK dout0_8 Vdout0_8ck202 = 1.1 time = 1015
.meas tran vdout0_8ck202 FIND v(dout0_8) AT=1015.025n

* CHECK dout0_9 Vdout0_9ck202 = 0 time = 1015
.meas tran vdout0_9ck202 FIND v(dout0_9) AT=1015.025n

* CHECK dout0_10 Vdout0_10ck202 = 1.1 time = 1015
.meas tran vdout0_10ck202 FIND v(dout0_10) AT=1015.025n

* CHECK dout0_11 Vdout0_11ck202 = 0 time = 1015
.meas tran vdout0_11ck202 FIND v(dout0_11) AT=1015.025n

* CHECK dout0_12 Vdout0_12ck202 = 1.1 time = 1015
.meas tran vdout0_12ck202 FIND v(dout0_12) AT=1015.025n

* CHECK dout0_13 Vdout0_13ck202 = 1.1 time = 1015
.meas tran vdout0_13ck202 FIND v(dout0_13) AT=1015.025n

* CHECK dout0_14 Vdout0_14ck202 = 0 time = 1015
.meas tran vdout0_14ck202 FIND v(dout0_14) AT=1015.025n

* CHECK dout0_15 Vdout0_15ck202 = 0 time = 1015
.meas tran vdout0_15ck202 FIND v(dout0_15) AT=1015.025n

* CHECK dout0_16 Vdout0_16ck202 = 0 time = 1015
.meas tran vdout0_16ck202 FIND v(dout0_16) AT=1015.025n

* CHECK dout0_17 Vdout0_17ck202 = 1.1 time = 1015
.meas tran vdout0_17ck202 FIND v(dout0_17) AT=1015.025n

* CHECK dout0_18 Vdout0_18ck202 = 1.1 time = 1015
.meas tran vdout0_18ck202 FIND v(dout0_18) AT=1015.025n

* CHECK dout0_19 Vdout0_19ck202 = 0 time = 1015
.meas tran vdout0_19ck202 FIND v(dout0_19) AT=1015.025n

* CHECK dout0_20 Vdout0_20ck202 = 0 time = 1015
.meas tran vdout0_20ck202 FIND v(dout0_20) AT=1015.025n

* CHECK dout0_21 Vdout0_21ck202 = 0 time = 1015
.meas tran vdout0_21ck202 FIND v(dout0_21) AT=1015.025n

* CHECK dout0_22 Vdout0_22ck202 = 1.1 time = 1015
.meas tran vdout0_22ck202 FIND v(dout0_22) AT=1015.025n

* CHECK dout0_23 Vdout0_23ck202 = 1.1 time = 1015
.meas tran vdout0_23ck202 FIND v(dout0_23) AT=1015.025n

* CHECK dout0_24 Vdout0_24ck202 = 0 time = 1015
.meas tran vdout0_24ck202 FIND v(dout0_24) AT=1015.025n

* CHECK dout0_25 Vdout0_25ck202 = 0 time = 1015
.meas tran vdout0_25ck202 FIND v(dout0_25) AT=1015.025n

* CHECK dout0_26 Vdout0_26ck202 = 1.1 time = 1015
.meas tran vdout0_26ck202 FIND v(dout0_26) AT=1015.025n

* CHECK dout0_27 Vdout0_27ck202 = 1.1 time = 1015
.meas tran vdout0_27ck202 FIND v(dout0_27) AT=1015.025n

* CHECK dout0_28 Vdout0_28ck202 = 1.1 time = 1015
.meas tran vdout0_28ck202 FIND v(dout0_28) AT=1015.025n

* CHECK dout0_29 Vdout0_29ck202 = 1.1 time = 1015
.meas tran vdout0_29ck202 FIND v(dout0_29) AT=1015.025n

* CHECK dout0_30 Vdout0_30ck202 = 1.1 time = 1015
.meas tran vdout0_30ck202 FIND v(dout0_30) AT=1015.025n

* CHECK dout0_31 Vdout0_31ck202 = 1.1 time = 1015
.meas tran vdout0_31ck202 FIND v(dout0_31) AT=1015.025n

* CHECK dout0_0 Vdout0_0ck203 = 1.1 time = 1020
.meas tran vdout0_0ck203 FIND v(dout0_0) AT=1020.025n

* CHECK dout0_1 Vdout0_1ck203 = 0 time = 1020
.meas tran vdout0_1ck203 FIND v(dout0_1) AT=1020.025n

* CHECK dout0_2 Vdout0_2ck203 = 1.1 time = 1020
.meas tran vdout0_2ck203 FIND v(dout0_2) AT=1020.025n

* CHECK dout0_3 Vdout0_3ck203 = 1.1 time = 1020
.meas tran vdout0_3ck203 FIND v(dout0_3) AT=1020.025n

* CHECK dout0_4 Vdout0_4ck203 = 0 time = 1020
.meas tran vdout0_4ck203 FIND v(dout0_4) AT=1020.025n

* CHECK dout0_5 Vdout0_5ck203 = 0 time = 1020
.meas tran vdout0_5ck203 FIND v(dout0_5) AT=1020.025n

* CHECK dout0_6 Vdout0_6ck203 = 1.1 time = 1020
.meas tran vdout0_6ck203 FIND v(dout0_6) AT=1020.025n

* CHECK dout0_7 Vdout0_7ck203 = 0 time = 1020
.meas tran vdout0_7ck203 FIND v(dout0_7) AT=1020.025n

* CHECK dout0_8 Vdout0_8ck203 = 1.1 time = 1020
.meas tran vdout0_8ck203 FIND v(dout0_8) AT=1020.025n

* CHECK dout0_9 Vdout0_9ck203 = 0 time = 1020
.meas tran vdout0_9ck203 FIND v(dout0_9) AT=1020.025n

* CHECK dout0_10 Vdout0_10ck203 = 1.1 time = 1020
.meas tran vdout0_10ck203 FIND v(dout0_10) AT=1020.025n

* CHECK dout0_11 Vdout0_11ck203 = 1.1 time = 1020
.meas tran vdout0_11ck203 FIND v(dout0_11) AT=1020.025n

* CHECK dout0_12 Vdout0_12ck203 = 0 time = 1020
.meas tran vdout0_12ck203 FIND v(dout0_12) AT=1020.025n

* CHECK dout0_13 Vdout0_13ck203 = 1.1 time = 1020
.meas tran vdout0_13ck203 FIND v(dout0_13) AT=1020.025n

* CHECK dout0_14 Vdout0_14ck203 = 0 time = 1020
.meas tran vdout0_14ck203 FIND v(dout0_14) AT=1020.025n

* CHECK dout0_15 Vdout0_15ck203 = 1.1 time = 1020
.meas tran vdout0_15ck203 FIND v(dout0_15) AT=1020.025n

* CHECK dout0_16 Vdout0_16ck203 = 1.1 time = 1020
.meas tran vdout0_16ck203 FIND v(dout0_16) AT=1020.025n

* CHECK dout0_17 Vdout0_17ck203 = 1.1 time = 1020
.meas tran vdout0_17ck203 FIND v(dout0_17) AT=1020.025n

* CHECK dout0_18 Vdout0_18ck203 = 0 time = 1020
.meas tran vdout0_18ck203 FIND v(dout0_18) AT=1020.025n

* CHECK dout0_19 Vdout0_19ck203 = 0 time = 1020
.meas tran vdout0_19ck203 FIND v(dout0_19) AT=1020.025n

* CHECK dout0_20 Vdout0_20ck203 = 0 time = 1020
.meas tran vdout0_20ck203 FIND v(dout0_20) AT=1020.025n

* CHECK dout0_21 Vdout0_21ck203 = 0 time = 1020
.meas tran vdout0_21ck203 FIND v(dout0_21) AT=1020.025n

* CHECK dout0_22 Vdout0_22ck203 = 0 time = 1020
.meas tran vdout0_22ck203 FIND v(dout0_22) AT=1020.025n

* CHECK dout0_23 Vdout0_23ck203 = 1.1 time = 1020
.meas tran vdout0_23ck203 FIND v(dout0_23) AT=1020.025n

* CHECK dout0_24 Vdout0_24ck203 = 0 time = 1020
.meas tran vdout0_24ck203 FIND v(dout0_24) AT=1020.025n

* CHECK dout0_25 Vdout0_25ck203 = 0 time = 1020
.meas tran vdout0_25ck203 FIND v(dout0_25) AT=1020.025n

* CHECK dout0_26 Vdout0_26ck203 = 0 time = 1020
.meas tran vdout0_26ck203 FIND v(dout0_26) AT=1020.025n

* CHECK dout0_27 Vdout0_27ck203 = 1.1 time = 1020
.meas tran vdout0_27ck203 FIND v(dout0_27) AT=1020.025n

* CHECK dout0_28 Vdout0_28ck203 = 1.1 time = 1020
.meas tran vdout0_28ck203 FIND v(dout0_28) AT=1020.025n

* CHECK dout0_29 Vdout0_29ck203 = 1.1 time = 1020
.meas tran vdout0_29ck203 FIND v(dout0_29) AT=1020.025n

* CHECK dout0_30 Vdout0_30ck203 = 1.1 time = 1020
.meas tran vdout0_30ck203 FIND v(dout0_30) AT=1020.025n

* CHECK dout0_31 Vdout0_31ck203 = 0 time = 1020
.meas tran vdout0_31ck203 FIND v(dout0_31) AT=1020.025n

* CHECK dout0_0 Vdout0_0ck204 = 0 time = 1025
.meas tran vdout0_0ck204 FIND v(dout0_0) AT=1025.025n

* CHECK dout0_1 Vdout0_1ck204 = 1.1 time = 1025
.meas tran vdout0_1ck204 FIND v(dout0_1) AT=1025.025n

* CHECK dout0_2 Vdout0_2ck204 = 1.1 time = 1025
.meas tran vdout0_2ck204 FIND v(dout0_2) AT=1025.025n

* CHECK dout0_3 Vdout0_3ck204 = 0 time = 1025
.meas tran vdout0_3ck204 FIND v(dout0_3) AT=1025.025n

* CHECK dout0_4 Vdout0_4ck204 = 1.1 time = 1025
.meas tran vdout0_4ck204 FIND v(dout0_4) AT=1025.025n

* CHECK dout0_5 Vdout0_5ck204 = 0 time = 1025
.meas tran vdout0_5ck204 FIND v(dout0_5) AT=1025.025n

* CHECK dout0_6 Vdout0_6ck204 = 0 time = 1025
.meas tran vdout0_6ck204 FIND v(dout0_6) AT=1025.025n

* CHECK dout0_7 Vdout0_7ck204 = 0 time = 1025
.meas tran vdout0_7ck204 FIND v(dout0_7) AT=1025.025n

* CHECK dout0_8 Vdout0_8ck204 = 0 time = 1025
.meas tran vdout0_8ck204 FIND v(dout0_8) AT=1025.025n

* CHECK dout0_9 Vdout0_9ck204 = 0 time = 1025
.meas tran vdout0_9ck204 FIND v(dout0_9) AT=1025.025n

* CHECK dout0_10 Vdout0_10ck204 = 1.1 time = 1025
.meas tran vdout0_10ck204 FIND v(dout0_10) AT=1025.025n

* CHECK dout0_11 Vdout0_11ck204 = 0 time = 1025
.meas tran vdout0_11ck204 FIND v(dout0_11) AT=1025.025n

* CHECK dout0_12 Vdout0_12ck204 = 0 time = 1025
.meas tran vdout0_12ck204 FIND v(dout0_12) AT=1025.025n

* CHECK dout0_13 Vdout0_13ck204 = 1.1 time = 1025
.meas tran vdout0_13ck204 FIND v(dout0_13) AT=1025.025n

* CHECK dout0_14 Vdout0_14ck204 = 0 time = 1025
.meas tran vdout0_14ck204 FIND v(dout0_14) AT=1025.025n

* CHECK dout0_15 Vdout0_15ck204 = 1.1 time = 1025
.meas tran vdout0_15ck204 FIND v(dout0_15) AT=1025.025n

* CHECK dout0_16 Vdout0_16ck204 = 0 time = 1025
.meas tran vdout0_16ck204 FIND v(dout0_16) AT=1025.025n

* CHECK dout0_17 Vdout0_17ck204 = 0 time = 1025
.meas tran vdout0_17ck204 FIND v(dout0_17) AT=1025.025n

* CHECK dout0_18 Vdout0_18ck204 = 0 time = 1025
.meas tran vdout0_18ck204 FIND v(dout0_18) AT=1025.025n

* CHECK dout0_19 Vdout0_19ck204 = 0 time = 1025
.meas tran vdout0_19ck204 FIND v(dout0_19) AT=1025.025n

* CHECK dout0_20 Vdout0_20ck204 = 0 time = 1025
.meas tran vdout0_20ck204 FIND v(dout0_20) AT=1025.025n

* CHECK dout0_21 Vdout0_21ck204 = 0 time = 1025
.meas tran vdout0_21ck204 FIND v(dout0_21) AT=1025.025n

* CHECK dout0_22 Vdout0_22ck204 = 0 time = 1025
.meas tran vdout0_22ck204 FIND v(dout0_22) AT=1025.025n

* CHECK dout0_23 Vdout0_23ck204 = 1.1 time = 1025
.meas tran vdout0_23ck204 FIND v(dout0_23) AT=1025.025n

* CHECK dout0_24 Vdout0_24ck204 = 1.1 time = 1025
.meas tran vdout0_24ck204 FIND v(dout0_24) AT=1025.025n

* CHECK dout0_25 Vdout0_25ck204 = 0 time = 1025
.meas tran vdout0_25ck204 FIND v(dout0_25) AT=1025.025n

* CHECK dout0_26 Vdout0_26ck204 = 0 time = 1025
.meas tran vdout0_26ck204 FIND v(dout0_26) AT=1025.025n

* CHECK dout0_27 Vdout0_27ck204 = 0 time = 1025
.meas tran vdout0_27ck204 FIND v(dout0_27) AT=1025.025n

* CHECK dout0_28 Vdout0_28ck204 = 1.1 time = 1025
.meas tran vdout0_28ck204 FIND v(dout0_28) AT=1025.025n

* CHECK dout0_29 Vdout0_29ck204 = 1.1 time = 1025
.meas tran vdout0_29ck204 FIND v(dout0_29) AT=1025.025n

* CHECK dout0_30 Vdout0_30ck204 = 0 time = 1025
.meas tran vdout0_30ck204 FIND v(dout0_30) AT=1025.025n

* CHECK dout0_31 Vdout0_31ck204 = 1.1 time = 1025
.meas tran vdout0_31ck204 FIND v(dout0_31) AT=1025.025n

* probe is used for hspice/xa, while plot is used in ngspice
.plot V(*)
.end
